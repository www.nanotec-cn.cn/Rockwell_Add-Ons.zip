(* Logix 5000 AddOnInstructionDefinition export NTEC_Comms; software revision ?; part 4 of 8 *)
(* NTEC_MAFR, continued *)

ROUTINE Postscan   (* ladder *)
// Home Post-Scan Routine
   // ***
   // POST SCAN ROUTINE
   // ***
   0: NOP();
   // ***
   // POST-SCAN ROUTINE
   // ***
   1: OTU(NTEC_Axis.PDI_CMD.Trig)NOP();
   2: OTU(EN);
END_ROUTINE

ROUTINE Prescan   (* ladder *)
// Home Pre-Scan Routine
   // ***
   // PRESCAN ROUTINE
   // ***
   0: NOP();
   1: OTU(ERR)CLR(ERR_Code);
   2: LIMIT(1,State,899)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(DN)OTU(EN)CLR(State);
END_ROUTINE
END_ADD_ON_INSTRUCTION

ADD_ON_INSTRUCTION NTEC_MAH   (* revision 1.6, vendor Third Coast Automation, Nashville, TN, ExecutePrescan, ExecuteEnableInFalse *)
// Motion Axis Home (MAH)
// Homes the servo axis position to a specified value at a specified location.  User to enter the Home Type (1=Immediate, 2=Sensor, 3=Block)  and if applicable, the Homing Method (matched up to values set in Drive using Plug & Drive software).
// All input parameters are entered into the AOI in whole numbers, in the units as setup and scaled in the Drive.
// Revision note:
// Release Aug 27, 2024, update CPS instructions LEN
// Help:
// AOI written by:
// Tim Cochran
// Third Coast Automation
// Nashville, TN
// Home Instruction for Nanotec Drives.
// Position = Coordinate position set after home is complete.
// HomeType 1=Immediate, 2=Sensor, 3=Block (HardStop).
// Home Method is from the Technical Manual, applicable to Sensor or Block homing. Best to setup and test the home method number/parameters and test using Plug & Drive software for reliable results.
// MAH ERR_Codes:
// 2: Input parameter range error – review and fix input parameters.
// 3: Command Error response from the Drive after command sent.
// 10: Communications Failed to Drive.
// 11: Drive Fault during this AOIs command sequence.
// 12: Quick Stop triggered by software outside of this AOI.
// 13: Command Error response from the Drive.
// 14: Enable input changed to False during sequence due to Drive Fault or Offline.
VAR_IN_OUT
   NTEC_Axis : NTEC_Axis; {required}   // NTEC Axis Tag
END_VAR
VAR_INPUT
   Position : DINT; {required}   // Position value for home location
   HomeType : DINT; {required}   // 1=Immediate 2=Sensor 3=Block
   HomeMethod : DINT; {required}   // Nanotec Drive Homing Method, 1 to 34, for Sensor/Block homing
END_VAR
VAR_OUTPUT
   EN : BOOL; {access Read Only, visible}   // Enabled
   IP : BOOL; {visible}   // In Process
   DN : BOOL; {visible}   // Successfully Done
   ERR : BOOL; {visible}   // Instruction Error
   ERR_Code : DINT; {access Read Only, visible}   // Instruction Error Code
END_VAR
VAR
   State : DINT; {access None}
   Enable : BOOL; {access None}
   local_HomeType : DINT; {access None}
   local_Position : DINT; {access None}
   local_HomeMethod : DINT; {access None}
   InputRangesOK : BOOL; {access None}
   tmr_VerifyHomedInput : TIMER := (PRE := 200); {access None}
   ServoActionWatchdog : TIMER := (PRE := 1000); {access None}
END_VAR

ROUTINE EnableInFalse   (* ladder *)
// Enable In False Routine
   // ***
   // Enable In False Routine
   // Runs when the rung to ths AOI instance is False
   // ***
   0: NOP();
   1: XIC(NTEC_Axis.StatResettingFault)OTU(ERR)CLR(ERR_Code);
   2: XIC(EN)LIMIT(1,State,899)XIC(NTEC_Axis.PDI_CMD.Trig)MOVE(0,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)MOVE(0,NTEC_Axis.PDI_CMD.SetValue3)MOVE(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)OTU(IP)CLR(State);
END_ROUTINE

ROUTINE Logic   (* ladder *)
   // ***
   // Nanotec Motion Axis Home
   // ***
   0: NOP();
   // ***
   // Main Logic Routine
   // ***
   1: NOP();
   // If the Enable (EN) bit is not on yet, this is first scan, so unlatch the Done (DN) bit.
   2: XIO(EN)OTU(DN);
   // Latch Enable (EN) bit as long as this AOI is being executed.
   3: XIC(EnableIn)OTE(EN);
   4: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)XIO(NTEC_Axis.StatDriveFault)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.QuickStop)XIO(NTEC_Axis.CMD_ERR)OTE(Enable);
   // Step 0
   // Start the Home Sequence
   5: XIC(Enable)EQ(State,0)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.Trig)XIO(NTEC_Axis.CMD_IP)MOVE(100,State);
   // State 100
   // Verify input values are within acceptable ranges
   6: XIC(Enable)EQ(State,100)MOVE(HomeType,local_HomeType)MOVE(HomeMethod,local_HomeMethod)MOVE(Position,local_Position)[[EQ(local_HomeType,1) LIMIT(-2147483647,local_Position,2147483647) ,LIMIT(2,local_HomeType,3) [LIMIT(1,local_HomeMethod,14) ,LIMIT(17,local_HomeMethod,30) ,LIMIT(33,local_HomeMethod,34) ] ] OTE(InputRangesOK) ,XIC(InputRangesOK) MOVE(110,State) ,XIO(InputRangesOK) MOVE(920,State) ];
   // State 110
   // Decide which Home Type to send to Drive.
   7: XIC(Enable)EQ(State,110)[EQ(local_HomeType,1) MOVE(120,State) ,EQ(local_HomeType,2) MOVE(122,State) ,EQ(local_HomeType,3) MOVE(124,State) ];
   // State 120
   // Based on the Homing Type, select the correct parameters and command to send to the NTEC_Comms AOI.
   8: XIC(Enable)EQ(State,120)MOVE(local_Position,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)MOVE(0,NTEC_Axis.PDI_CMD.SetValue3)MOVE(17,NTEC_Axis.PDI_CMD.CMD)MOVE(130,State);
   // State 120
   // Based on the Homing Type, select the correct parameters and command to send to the NTEC_Comms AOI.
   9: XIC(Enable)EQ(State,122)MOVE(0,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)MOVE(local_HomeMethod,NTEC_Axis.PDI_CMD.SetValue3)MOVE(18,NTEC_Axis.PDI_CMD.CMD)MOVE(130,State);
   // State 120
   // Based on the Homing Type, select the correct parameters and command to send to the NTEC_Comms AOI.
   10: XIC(Enable)EQ(State,124)MOVE(0,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)NEG(local_HomeMethod,NTEC_Axis.PDI_CMD.SetValue3)MOVE(18,NTEC_Axis.PDI_CMD.CMD)MOVE(130,State);
   // State 130
   // Trigger the Home Command.
   11: XIC(Enable)EQ(State,130)OTL(NTEC_Axis.PDI_CMD.Trig)OTL(IP)MOVE(140,State);
   // State 140
   // Verify the Homed status goes off.
   12: XIC(Enable)EQ(State,140)[XIO(NTEC_Axis.StatMotion_Homed) ,TON(tmr_VerifyHomedInput,?,?) XIC(tmr_VerifyHomedInput.DN) ,EQ(local_HomeType,1) ]MOVE(150,State);
   // State 150
   // Verify the NTEC_Axis.CMD_IP is ON.  This is the handshake from the Comms routine that the command is sent.
   13: XIC(Enable)EQ(State,150)XIC(NTEC_Axis.CMD_IP)MOVE(160,State);
   // State 160
   // Verify the Homed is returned from the Drive.
   // Verify the NTEC_Comms is Done (DN) sending the command.
   // IF the Servo Action status is not ON after Watchdog time delay, Error.  (All Home commands, even immediate home, turn the motor ON)
   14: XIC(Enable)EQ(State,160)[XIC(NTEC_Axis.CMD_DN) MOVE(170,State) ,XIO(NTEC_Axis.StatServoActionStatus) TON(ServoActionWatchdog,?,?) XIC(ServoActionWatchdog.DN) MOVE(930,State) ];
   // State 170
   // To finish the handshake with NTEC_Comms, this AOI clears the CMD_Trg and the NTEC_Comms clears its IP bit.
   15: XIC(Enable)EQ(State,170)MOVE(0,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)MOVE(0,NTEC_Axis.PDI_CMD.SetValue3)MOVE(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig)MOVE(180,State);
   // State 180
   // To finish the handshake with NTEC_Comms, the NTEC_Comms clears its IP bit.
   // END OF COMMAND SEQUENCE - RESET STATE TO ZERO
   16: XIC(Enable)EQ(State,180)XIO(NTEC_Axis.CMD_IP)MOVE(190,State);
   // State 190
   // Clear the In Process Bit
   // Set the Done Bit
   // Move State to 1000, which is a rest state unitl the rung into this AOI is false.
   // END OF COMMAND SEQUENCE
   17: XIC(Enable)EQ(State,190)OTU(IP)OTL(DN)MOVE(1000,State);
   // *************************************************
   // FAULTS
   18: NOP();
   // IF in the middle of a sequence AND the Drive Communications goes False, goto error state 910
   19: XIO(NTEC_Axis.StatDriveCommsOK)LIMIT(1,State,899)MOVE(910,State);
   // Fault State 910
   // Communications to the Drive was  lost during a sequence - Abort the sequence.
   20: EQ(State,910)OTL(ERR)MOVE(10,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the Drive Fault, goto error state 911
   21: XIC(NTEC_Axis.StatDriveFault)LIMIT(1,State,899)MOVE(911,State);
   // Fault State 910
   // Drive Fault during a sequence - Abort the sequence
   22: EQ(State,911)OTL(ERR)MOVE(11,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the QuickStop, goto error state 912
   23: XIC(NTEC_Axis.PDI_CMD.QuickStop)LIMIT(1,State,899)MOVE(912,State);
   // Fault State 912
   // Quick Stop during a sequence - Abort the sequence
   24: EQ(State,912)OTL(ERR)MOVE(12,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND Communications Command Error occurs, goto error state 913
   25: XIC(NTEC_Axis.CMD_ERR)LIMIT(1,State,899)MOVE(913,State);
   // Fault State 913
   // Communications Command Error during a sequence - Abort the sequence and issue a Quick Stop
   26: EQ(State,913)OTL(ERR)MOVE(13,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the EnableIn goes False, goto error state 914
   27: XIO(Enable)LIMIT(1,State,899)MOVE(914,State);
   // Fault State 914
   // Enable Input changed to False / OFF during a sequence - Abort the sequence
   28: EQ(State,914)OTL(ERR)MOVE(14,ERR_Code)MOVE(999,State);
   // Fault State 920
   // Input Parameter Range Error
   29: EQ(State,920)OTL(ERR)MOVE(2,ERR_Code)MOVE(999,State);
   // Fault State - command error during sequence
   // IF in the middle of a sequence, this AOI receives a Command Error, goto error state 930
   30: XIC(NTEC_Axis.StatCommandError)LIMIT(100,State,899)MOVE(930,State);
   // Fault State 930
   // Command Error during a sequence - Abort the sequence
   31: EQ(State,930)OTL(NTEC_Axis.PDI_CMD.QuickStop)OTL(ERR)MOVE(3,ERR_Code)MOVE(999,State);
   // Fault State 999
   // Clear the outputs after a Fault
   32: EQ(State,999)[MOVE(0,NTEC_Axis.PDI_CMD.SetValue1) MOVE(0,NTEC_Axis.PDI_CMD.SetValue2) MOVE(0,NTEC_Axis.PDI_CMD.SetValue3) MOVE(0,NTEC_Axis.PDI_CMD.CMD) ,OTU(NTEC_Axis.PDI_CMD.Trig) MOVE(1000,State) ];
   // ********************************************************
   // State 1000
   // Wait for Enable In to go Off/On.  Just sit in this state until AOI triggered again.
   // Reset faults if the MAFT triggers a reset.  Reset if waiting is state 1000 OR state 0.
   33: [EQ(State,1000) ,EQ(State,0) ][NOP() ,XIC(NTEC_Axis.StatResettingFault) OTU(ERR) MOVE(0,ERR_Code) ];
END_ROUTINE

ROUTINE Postscan   (* ladder *)
// Home Post-Scan Routine
   // ***
   // POST SCAN ROUTINE
   // ***
   0: NOP();
   // ***
   // POST-SCAN ROUTINE
   // ***
   1: OTU(NTEC_Axis.PDI_CMD.Trig)NOP();
   2: OTU(EN)OTU(IP);
END_ROUTINE

ROUTINE Prescan   (* ladder *)
// Home Pre-Scan Routine
   // ***
   // PRESCAN ROUTINE
   // ***
   0: NOP();
   1: OTU(ERR)CLR(ERR_Code);
   2: LIMIT(1,State,899)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)OTU(DN)OTU(IP)CLR(State);
END_ROUTINE
END_ADD_ON_INSTRUCTION

ADD_ON_INSTRUCTION NTEC_WRITE   (* revision 1.6, vendor Third Coast Automation, Nashville, TN, ExecutePrescan, ExecuteEnableInFalse *)
// WRITE instruction writes the value entered into the AOI, into the specified object in the Drive.  Enter the target object's index and sub-index (typically 16#xxxx hex values).
// Revision note:
// Release Aug 27, 2024, update CPS instructions LEN
// Help:
// AOI written by:
// Tim Cochran
// Third Coast Automation
// Nashville, TN
// MAS ERR_Codes:
// 2: Input parameter range error – review and fix input parameters.
// 3: Command Error response from the Drive after command sent.
// 10: Communications Failed to Drive.
// 11: Drive Fault during this AOIs command sequence.
// 12: Quick Stop triggered by software outside of this AOI.
// 13: Command Error response from the Drive.
// 14: Enable input changed to False during sequence due to Drive Fault or Offline.
VAR_IN_OUT
   NTEC_Axis : NTEC_Axis; {required}   // NTEC Axis Tag
END_VAR
VAR_INPUT
   Index : DINT; {required}   // Index
   SubIndex : DINT; {required}   // Sub-Index
END_VAR
VAR_OUTPUT
   EN : BOOL; {visible}   // Enabled
   DN : BOOL; {visible}   // Successfully Done
END_VAR
VAR_INPUT
   Value : DINT; {required}   // WriteValue
END_VAR
VAR_OUTPUT
   ERR : BOOL; {visible}   // Instruction Error
   ERR_Code : DINT; {access Read Only, visible}   // Instruction Error Code
END_VAR
VAR
   State : DINT; {access None}
   Enable : BOOL; {access None}
   InputRangesOK : BOOL; {access None}
   local_SubIndex : DINT; {access None}
   local_Index : DINT; {access None}
   tmr_Verify : TIMER; {access None}
   local_Value : DINT; {access None}
END_VAR

ROUTINE EnableInFalse   (* ladder *)
// Enable In False Routine
   // ***
   // Enable In False Routine
   // Runs when the rung to ths AOI instance is False
   // ***
   0: NOP();
   1: XIC(NTEC_Axis.StatResettingFault)OTU(ERR)CLR(ERR_Code);
   2: XIC(EN)LIMIT(1,State,899)XIC(NTEC_Axis.PDI_CMD.Trig)MOVE(0,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)MOVE(0,NTEC_Axis.PDI_CMD.SetValue3)MOVE(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)CLR(State);
END_ROUTINE

ROUTINE Logic   (* ladder *)
   // ***
   // Nanotec WRITE
   // ***
   0: NOP();
   // ***
   // Main Logic Routine
   // ***
   1: NOP();
   // If the Enable (EN) bit is not on yet, this is first scan, so unlatch the Done (DN) bit.
   2: XIO(EN)OTU(DN);
   // Latch Enable (EN) bit as long as this AOI is being executed.
   3: XIC(EnableIn)OTE(EN);
   4: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)XIO(NTEC_Axis.StatDriveFault)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.QuickStop)XIO(NTEC_Axis.CMD_ERR)OTE(Enable);
   // Step 0
   // Start the Sequence
   5: XIC(Enable)EQ(State,0)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.Trig)XIO(NTEC_Axis.CMD_IP)MOVE(100,State);
   // State 100
   // Verify input values are within acceptable ranges
   6: XIC(Enable)EQ(State,100)MOVE(Value,local_Value)MOVE(SubIndex,local_SubIndex)MOVE(Index,local_Index)[LIMIT(-2147483647,local_Value,2147483647) LIMIT(16#1000,local_Index,16#6505) LIMIT(0,local_SubIndex,16#6505) OTE(InputRangesOK) ,XIC(InputRangesOK) MOVE(110,State) ,XIO(InputRangesOK) MOVE(920,State) ];
   // State 110
   // Spare
   7: XIC(Enable)EQ(State,110)MOVE(120,State);
   // State 120
   // Load the parameters and command to send to the NTEC_Comms AOI.
   8: XIC(Enable)EQ(State,120)MOVE(local_Value,NTEC_Axis.PDI_CMD.SetValue1)MOVE(local_Index,NTEC_Axis.PDI_CMD.SetValue2)MOVE(local_SubIndex,NTEC_Axis.PDI_CMD.SetValue3)MOVE(15,NTEC_Axis.PDI_CMD.CMD)MOVE(130,State);
   // State 130
   // Trigger the Command.
   9: XIC(Enable)EQ(State,130)OTL(NTEC_Axis.PDI_CMD.Trig)MOVE(150,State);
   // State 150
   // Verify the NTEC_Comms is In-Process (IP) sending  the command to the Drive.
   10: XIC(Enable)EQ(State,150)XIC(NTEC_Axis.CMD_IP)MOVE(160,State);
   // State 160
   // Verify the NTEC_Comms is Done (DN) sending the command.
   11: XIC(Enable)EQ(State,160)TON(tmr_Verify,?,?)XIC(tmr_Verify.DN)XIC(NTEC_Axis.CMD_DN)MOVE(170,State);
   // State 170
   // To finish the handshake with NTEC_Comms, this AOI clears the CMD_Trg and the NTEC_Comms clears its IP bit.
   12: XIC(Enable)EQ(State,170)MOVE(0,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)MOVE(0,NTEC_Axis.PDI_CMD.SetValue3)MOVE(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig)MOVE(180,State);
   // State 180
   // To finish the handshake with NTEC_Comms, the NTEC_Comms clears its IP bit.
   13: XIC(Enable)EQ(State,180)XIO(NTEC_Axis.CMD_IP)MOVE(190,State);
   // State 190
   // Set the Done Bit
   // Move State to 1000, which is a rest state unitl the rung into this AOI is false.
   // END OF COMMAND SEQUENCE
   14: XIC(Enable)EQ(State,190)OTL(DN)MOVE(1000,State);
   // *************************************************
   // FAULTS
   15: NOP();
   // IF in the middle of a sequence AND the Drive Communications goes False, goto error state 910
   16: XIO(NTEC_Axis.StatDriveCommsOK)LIMIT(1,State,899)MOVE(910,State);
   // Fault State 910
   // Communications to the Drive was  lost during a sequence - Abort the sequence.
   17: EQ(State,910)OTL(ERR)MOVE(10,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the Drive Fault, goto error state 911
   18: XIC(NTEC_Axis.StatDriveFault)LIMIT(1,State,899)MOVE(911,State);
   // Fault State 910
   // Drive Fault during a sequence - Abort the sequence
   19: EQ(State,911)OTL(ERR)MOVE(11,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the QuickStop, goto error state 912
   20: XIC(NTEC_Axis.PDI_CMD.QuickStop)LIMIT(1,State,899)MOVE(912,State);
   // Fault State 912
   // Quick Stop during a sequence - Abort the sequence
   21: EQ(State,912)OTL(ERR)MOVE(12,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND Communications Command Error occurs, goto error state 913
   22: XIC(NTEC_Axis.CMD_ERR)LIMIT(1,State,899)MOVE(913,State);
   // Fault State 913
   // Communications Command Error during a sequence - Abort the sequence and issue a Quick Stop
   23: EQ(State,913)OTL(ERR)MOVE(13,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the EnableIn goes False, goto error state 914
   24: XIO(Enable)LIMIT(1,State,899)MOVE(914,State);
   // Fault State 914
   // Enable Input changed to False / OFF during a sequence - Abort the sequence
   25: EQ(State,914)OTL(ERR)MOVE(14,ERR_Code)MOVE(999,State);
   // Fault State 920
   // Input Parameter Range Error
   26: EQ(State,920)OTL(ERR)MOVE(2,ERR_Code)MOVE(999,State);
   // Fault State - command error during sequence
   // IF in the middle of a sequence, this AOI receives a Command Error, goto error state 930
   27: XIC(NTEC_Axis.StatCommandError)LIMIT(100,State,899)MOVE(930,State);
   // Fault State 930
   // Command Error during a sequence - Abort the sequence
   28: EQ(State,930)OTL(ERR)MOVE(3,ERR_Code)MOVE(999,State);
   // Fault State 999
   // Clear the outputs after a Fault
   29: EQ(State,999)[MOVE(0,NTEC_Axis.PDI_CMD.SetValue1) MOVE(0,NTEC_Axis.PDI_CMD.SetValue2) MOVE(0,NTEC_Axis.PDI_CMD.SetValue3) MOVE(0,NTEC_Axis.PDI_CMD.CMD) ,OTU(NTEC_Axis.PDI_CMD.Trig) MOVE(1000,State) ];
   // ********************************************************
   // State 1000
   // Wait for Enable In to go Off/On.  Just sit in this state until AOI triggered again.
   // Reset faults if the MAFT triggers a reset.  Reset if waiting is state 1000 OR state 0.
   30: [EQ(State,1000) ,EQ(State,0) ][NOP() ,XIC(NTEC_Axis.StatResettingFault) OTU(ERR) MOVE(0,ERR_Code) ];
END_ROUTINE
