(* Logix 5000 AddOnInstructionDefinition export NTEC_Comms; software revision ?; part 8 of 8 *)
(* tags used below, declared in another part *)
   NTEC_Axis : NTEC_Axis;   // NTEC Axis Tag
   EN : BOOL;   // Enabled
   DN : BOOL;   // Successfully Done
   ERR : BOOL;   // Instruction Error
   ERR_Code : DINT;   // Instruction Error Code
   State : DINT;
(* NTEC_MSF, continued *)

ROUTINE Postscan   (* ladder *)
// Home Post-Scan Routine
   // ***
   // POST SCAN ROUTINE
   // ***
   0: NOP();
   // ***
   // POST-SCAN ROUTINE
   // ***
   1: OTU(NTEC_Axis.PDI_CMD.Trig)NOP();
   2: OTU(EN);
END_ROUTINE

ROUTINE Prescan   (* ladder *)
// Home Pre-Scan Routine
   // ***
   // PRESCAN ROUTINE
   // ***
   0: NOP();
   1: OTU(ERR)CLR(ERR_Code);
   2: LIMIT(1,State,899)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(DN)OTU(EN)CLR(State);
END_ROUTINE
END_ADD_ON_INSTRUCTION
