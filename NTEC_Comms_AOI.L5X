(* Logix 5000 AddOnInstructionDefinition export NTEC_Comms; software revision ?; part 7 of 8 *)
(* NTEC_MAS, continued *)

ROUTINE Postscan   (* ladder *)
// Home Post-Scan Routine
   // ***
   // POST SCAN ROUTINE
   // ***
   0: NOP();
   // ***
   // POST-SCAN ROUTINE
   // ***
   1: OTU(NTEC_Axis.PDI_CMD.Trig)NOP();
   2: OTU(EN)OTU(IP);
END_ROUTINE

ROUTINE Prescan   (* ladder *)
// Home Pre-Scan Routine
   // ***
   // PRESCAN ROUTINE
   // ***
   0: NOP();
   1: OTU(ERR)CLR(ERR_Code);
   2: LIMIT(1,State,899)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)OTU(DN)OTU(IP)CLR(State);
END_ROUTINE
END_ADD_ON_INSTRUCTION

ADD_ON_INSTRUCTION NTEC_MAT   (* revision 1.0, vendor Third Coast Automation, Nashville, TN, ExecutePrescan, ExecuteEnableInFalse *)
// Motion Axis Torque (MAT)
// Run the axis in Profile Torque mode.  Max torque is  tenths of % of rated torque in 203Bh:01 (500=50%).  After this AOI instruction executes, the axis continues to run in Torque Mode until a Stop (NTEC_MAS) is executed.
// Enter torque values as whole numbers in tenths of a percent (0.1%).
// Help:
// AOI written by:
// Tim Cochran
// Third Coast Automation
// Nashville, TN
// MAT ERR_Codes:
// 2: Input parameter range error – review and fix input parameters.
// 3: Command Error response from the Drive after command sent.
// 4: Command Error after Torque Slope value was sent to the Drive.
// 10: Communications Failed to Drive.
// 11: Drive Fault during this AOIs command sequence.
// 12: Quick Stop triggered by software outside of this AOI.
// 13: Command Error response from the Drive.
// 14: Enable input changed to False during sequence due to Drive Fault or Offline.
VAR_IN_OUT
   NTEC_Axis : NTEC_Axis; {required}   // NTEC Axis Tag
END_VAR
VAR_INPUT
   TargetTorque : DINT; {required}   // Target Torque (Torque in tenths of a % of rated torque, 500=50%)
   MaxVelocity : DINT; {required}   // Maximum Speed in Drive units / sec
   TorqueSlope : DINT; {required}   // Torque change per second (Torque in tenths of %, 500=50%)
END_VAR
VAR_OUTPUT
   EN : BOOL; {access Read Only, visible}   // Enabled
   IP : BOOL; {visible}   // In Process
   DN : BOOL; {visible}   // Successfully Done
   ERR : BOOL; {visible}   // Instruction Error
   ERR_Code : DINT; {access Read Only, visible}   // Instruction Error Code
END_VAR
VAR
   State : DINT; {access None}
   Enable : BOOL; {access None}
   local_TorqueSlope : DINT; {access None}
   InputRangesOK : BOOL; {access None}
   tmr_Verify : TIMER := (PRE := 20); {access None}
   local_MaxVelocity : INT; {access None}
   Write1_cntrl : NTEC_WRITE; {access None}
   local_TargetTorque : DINT; {access None}
END_VAR

ROUTINE EnableInFalse   (* ladder *)
// Enable In False Routine
   // ***
   // Enable In False Routine
   // Runs when the rung to ths AOI instance is False
   // ***
   0: NOP();
   1: XIC(NTEC_Axis.StatResettingFault)OTU(ERR)CLR(ERR_Code);
   2: XIC(EN)LIMIT(1,State,899)XIC(NTEC_Axis.PDI_CMD.Trig)MOVE(0,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)MOVE(0,NTEC_Axis.PDI_CMD.SetValue3)MOVE(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)OTU(IP)CLR(State);
END_ROUTINE

ROUTINE Logic   (* ladder *)
   // ***
   // Nanotec Motion Axis Torque
   // (Profile Torque)
   // ***
   0: NOP();
   // ***
   // Main Logic Routine
   // ***
   1: NOP();
   // If the Enable (EN) bit is not on yet, this is first scan, so unlatch the Done (DN) bit.
   2: XIO(EN)OTU(DN);
   // Latch Enable (EN) bit as long as this AOI is being executed.
   3: XIC(EnableIn)OTE(EN);
   4: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)XIO(NTEC_Axis.StatDriveFault)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.QuickStop)XIO(NTEC_Axis.CMD_ERR)OTE(Enable);
   // Step 0
   // Start the Move Sequence
   5: XIC(Enable)EQ(State,0)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.Trig)XIO(NTEC_Axis.CMD_IP)MOVE(100,State);
   // State 100
   // Verify input values are within acceptable ranges
   6: XIC(Enable)EQ(State,100)MOVE(TargetTorque,local_TargetTorque)MOVE(MaxVelocity,local_MaxVelocity)MOVE(TorqueSlope,local_TorqueSlope)[LIMIT(NTEC_Axis.DriveLimits.CurrentMaxNegDir,local_TargetTorque,NTEC_Axis.DriveLimits.CurrentMaxPosDir) LIMIT(NTEC_Axis.DriveLimits.TorqueMaxNegDir,local_TargetTorque,NTEC_Axis.DriveLimits.TorqueMaxPosDir) LIMIT(NTEC_Axis.DriveLimits.VelocityLimitMin,local_MaxVelocity,NTEC_Axis.DriveLimits.VelocityLimitMax) NE(local_MaxVelocity,0) LIMIT(1,local_TorqueSlope,2147483647) OTE(InputRangesOK) ,XIC(InputRangesOK) MOVE(110,State) ,XIO(InputRangesOK) MOVE(920,State) ];
   // State 110
   // Write Torque Slope Value to the Drive object 6087h
   7: XIC(Enable)EQ(State,110)[NTEC_WRITE(Write1_cntrl,NTEC_Axis,16#6087,0,local_TorqueSlope) ,XIC(Write1_cntrl.DN) XIC(Write1_cntrl.EN) MOVE(120,State) ,XIC(Write1_cntrl.ERR) MOVE(940,State) ];
   // State 120
   // Select the correct parameters and command to send to the NTEC_Comms AOI.
   8: XIC(Enable)EQ(State,120)MOVE(local_TargetTorque,NTEC_Axis.PDI_CMD.SetValue1)MOVE(local_MaxVelocity,NTEC_Axis.PDI_CMD.SetValue2)MOVE(0,NTEC_Axis.PDI_CMD.SetValue3)MOVE(25,NTEC_Axis.PDI_CMD.CMD)MOVE(130,State);
   // State 130
   // Trigger the Move Command.
   9: XIC(Enable)EQ(State,130)OTL(NTEC_Axis.PDI_CMD.Trig)OTL(IP)MOVE(140,State);
   // State 140
   10: XIC(Enable)EQ(State,140)MOVE(150,State);
   // State 150
   // Verify the NTEC_Comms is In-Process (IP) sending  the command to the Drive.
   11: XIC(Enable)EQ(State,150)XIC(NTEC_Axis.CMD_IP)MOVE(160,State);
   // State 160
   // Verify the "At Target" is returned from the Drive.
   // Verify the NTEC_Comms is Done (DN) sending the command.
   12: XIC(Enable)EQ(State,160)TON(tmr_Verify,?,?)XIC(tmr_Verify.DN)XIC(NTEC_Axis.CMD_DN)MOVE(170,State);
   // State 170
   // To finish the handshake with NTEC_Comms, this AOI clears the CMD_Trg and then NTEC_Comms clears its IP bit.
   13: XIC(Enable)EQ(State,170)MOVE(0,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)MOVE(0,NTEC_Axis.PDI_CMD.SetValue3)MOVE(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig)MOVE(180,State);
   // State 180
   // To finish the handshake with NTEC_Comms,NTEC_Comms clears its IP bit.
   14: XIC(Enable)EQ(State,180)XIO(NTEC_Axis.CMD_IP)MOVE(190,State);
   // State 190
   // Clear the In Process Bit
   // Set the Done Bit
   // Move State to 1000, which is a rest state unitl the rung into this AOI is false.
   // END OF COMMAND SEQUENCE
   15: XIC(Enable)EQ(State,190)OTU(IP)OTL(DN)MOVE(1000,State);
   // *************************************************
   // FAULTS
   16: NOP();
   // IF in the middle of a sequence AND the Drive Communications goes False, goto error state 910
   17: XIO(NTEC_Axis.StatDriveCommsOK)LIMIT(1,State,899)MOVE(910,State);
   // Fault State 910
   // Communications to the Drive was  lost during a sequence - Abort the sequence.
   18: EQ(State,910)OTL(ERR)MOVE(10,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the Drive Fault, goto error state 911
   19: XIC(NTEC_Axis.StatDriveFault)LIMIT(1,State,899)MOVE(911,State);
   // Fault State 910
   // Drive Fault during a sequence - Abort the sequence
   20: EQ(State,911)OTL(ERR)MOVE(11,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the QuickStop, goto error state 912
   21: XIC(NTEC_Axis.PDI_CMD.QuickStop)LIMIT(1,State,899)MOVE(912,State);
   // Fault State 912
   // Quick Stop during a sequence - Abort the sequence
   22: EQ(State,912)OTL(ERR)MOVE(12,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND Communications Command Error occurs, goto error state 913
   23: XIC(NTEC_Axis.CMD_ERR)LIMIT(1,State,899)MOVE(913,State);
   // Fault State 913
   // Communications Command Error during a sequence - Abort the sequence and issue a Quick Stop
   24: EQ(State,913)OTL(ERR)MOVE(13,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the EnableIn goes False, goto error state 914
   25: XIO(Enable)LIMIT(1,State,899)MOVE(914,State);
   // Fault State 914
   // Enable Input changed to False / OFF during a sequence - Abort the sequence
   26: EQ(State,914)OTL(ERR)MOVE(14,ERR_Code)MOVE(999,State);
   // Fault State 920
   // Input Parameter Range Error
   27: EQ(State,920)OTL(ERR)MOVE(2,ERR_Code)MOVE(999,State);
   // Fault State - command error during sequence
   // IF in the middle of a sequence, this AOI receives a Command Error, goto error state 930
   28: XIC(NTEC_Axis.StatCommandError)LIMIT(100,State,899)MOVE(930,State);
   // Fault State 930
   // Command Error during a sequence - Abort the sequence
   29: EQ(State,930)OTL(NTEC_Axis.PDI_CMD.QuickStop)OTL(ERR)MOVE(3,ERR_Code)MOVE(999,State);
   // Fault State 940
   // Send Torque Slope to the Drive created an Error - Abort the sequence
   30: EQ(State,940)OTL(ERR)MOVE(4,ERR_Code)MOVE(999,State);
   // Fault State 999
   // Clear the outputs after a Fault
   31: EQ(State,999)[MOVE(0,NTEC_Axis.PDI_CMD.SetValue1) MOVE(0,NTEC_Axis.PDI_CMD.SetValue2) MOVE(0,NTEC_Axis.PDI_CMD.SetValue3) MOVE(0,NTEC_Axis.PDI_CMD.CMD) ,OTU(NTEC_Axis.PDI_CMD.Trig) MOVE(1000,State) ];
   // ********************************************************
   // State 1000
   // Wait for Enable In to go Off/On.  Just sit in this state until AOI triggered again.
   // Reset faults if the MAFT triggers a reset.  Reset if waiting is state 1000 OR state 0.
   32: [EQ(State,1000) ,EQ(State,0) ][NOP() ,XIC(NTEC_Axis.StatResettingFault) OTU(ERR) MOVE(0,ERR_Code) ];
END_ROUTINE

ROUTINE Postscan   (* ladder *)
// Home Post-Scan Routine
   // ***
   // POST SCAN ROUTINE
   // ***
   0: NOP();
   // ***
   // POST-SCAN ROUTINE
   // ***
   1: OTU(NTEC_Axis.PDI_CMD.Trig)NOP();
   2: OTU(EN)OTU(IP);
END_ROUTINE

ROUTINE Prescan   (* ladder *)
// Home Pre-Scan Routine
   // ***
   // PRESCAN ROUTINE
   // ***
   0: NOP();
   1: OTU(ERR)CLR(ERR_Code);
   2: LIMIT(1,State,899)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)OTU(DN)OTU(IP)CLR(State);
END_ROUTINE
END_ADD_ON_INSTRUCTION

ADD_ON_INSTRUCTION NTEC_MSF   (* revision 1.6, vendor Third Coast Automation, Nashville, TN , ExecutePrescan, ExecuteEnableInFalse *)
// Motion Servo Off - turn Drive power / control to the motor OFF.
// Help:
// AOI written by:
// Tim Cochran
// Third Coast Automation
// Nashville, TN
// MSF ERR_Codes:
// 2: Input parameter range error – review and fix input parameters.
// 3: Command Error response from the Drive after command sent.
// 10: Communications Failed to Drive.
// 11: Drive Fault during this AOIs command sequence.
// 12: Quick Stop triggered by software outside of this AOI.
// 13: Command Error response from the Drive.
// 14: Enable input changed to False during sequence due to Drive Fault or Offline.
VAR_IN_OUT
   NTEC_Axis : NTEC_Axis; {required}   // NTEC Axis Tag
END_VAR
VAR_OUTPUT
   EN : BOOL; {visible}   // Enabled
   DN : BOOL; {visible}   // Successfully Done
   ERR : BOOL; {visible}   // Instruction Error
   ERR_Code : DINT; {access Read Only, visible}   // Instruction Error Code
END_VAR
VAR
   State : DINT; {access None}
   Enable : BOOL; {access None}
   InputRangesOK : BOOL; {access None}
   tmr_Verify : TIMER := (PRE := 2000); {access None}
END_VAR

ROUTINE EnableInFalse   (* ladder *)
// Enable In False Routine
   // ***
   // Enable In False Routine
   // Runs when the rung to ths AOI instance is False
   // ***
   0: NOP();
   1: XIC(NTEC_Axis.StatResettingFault)OTU(ERR)CLR(ERR_Code);
   2: XIC(EN)LIMIT(1,State,899)XIC(NTEC_Axis.PDI_CMD.Trig)MOVE(0,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)MOVE(0,NTEC_Axis.PDI_CMD.SetValue3)MOVE(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)CLR(State);
END_ROUTINE

ROUTINE Logic   (* ladder *)
   // ***
   // Nanotec Motion Servo OFF
   // ***
   0: NOP();
   // ***
   // Main Logic Routine
   // ***
   1: NOP();
   // If the Enable (EN) bit is not on yet, this is first scan, so unlatch the Done (DN) bit.
   2: XIO(EN)OTU(DN);
   // Latch Enable (EN) bit as long as this AOI is being executed.
   3: XIC(EnableIn)OTE(EN);
   4: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)XIO(NTEC_Axis.StatDriveFault)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.QuickStop)XIO(NTEC_Axis.CMD_ERR)OTE(Enable);
   // Step 0
   // Start the Move Sequence
   5: XIC(Enable)EQ(State,0)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.Trig)[XIO(NTEC_Axis.CMD_IP) MOVE(100,State) ,XIC(NTEC_Axis.CMD_IP) OTE(NTEC_Axis.PDI_CMD.Halt) ];
   // State 100
   // Verify Servo is actually ON to continue.  If the Servo is already OFF, jump to the end of this sequence.
   6: XIC(Enable)EQ(State,100)[XIC(NTEC_Axis.StatServoActionStatus) MOVE(110,State) ,XIO(NTEC_Axis.StatServoActionStatus) MOVE(170,State) ];
   // State 110
   7: XIC(Enable)EQ(State,110)MOVE(120,State);
   // State 120
   // Load the parameters and command to send to the NTEC_Comms AOI.
   8: XIC(Enable)EQ(State,120)MOVE(0,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)MOVE(0,NTEC_Axis.PDI_CMD.SetValue3)MOVE(1,NTEC_Axis.PDI_CMD.CMD)MOVE(130,State);
   // State 130
   // Trigger the Command.
   9: XIC(Enable)EQ(State,130)OTL(NTEC_Axis.PDI_CMD.Trig)MOVE(150,State);
   // State 150
   // Verify the NTEC_Comms is In-Process (IP) sending the command to the Drive.
   10: XIC(Enable)EQ(State,150)XIC(NTEC_Axis.CMD_IP)MOVE(160,State);
   // State 160
   // Verify the NTEC_Comms is Done (DN) sending the command.
   11: XIC(Enable)EQ(State,160)[XIO(NTEC_Axis.StatServoActionStatus) MOVE(170,State) ,TON(tmr_Verify,?,?) XIC(tmr_Verify.DN) XIC(NTEC_Axis.CMD_DN) XIC(NTEC_Axis.StatServoActionStatus) MOVE(940,State) ];
   // State 170
   // To finish the handshake with NTEC_Comms, this AOI clears the CMD_Trg and the NTEC_Comms clears its IP bit.
   12: XIC(Enable)EQ(State,170)MOVE(0,NTEC_Axis.PDI_CMD.SetValue1)MOVE(0,NTEC_Axis.PDI_CMD.SetValue2)MOVE(0,NTEC_Axis.PDI_CMD.SetValue3)MOVE(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig)MOVE(180,State);
   // State 180
   // To finish the handshake with NTEC_Comms, the NTEC_Comms clears its IP bit.
   13: XIC(Enable)EQ(State,180)XIO(NTEC_Axis.CMD_IP)MOVE(190,State);
   // State 190
   // Set the Done Bit
   // Move State to 1000, which is a rest state unitl the rung into this AOI is false.
   // END OF COMMAND SEQUENCE
   14: XIC(Enable)EQ(State,190)OTL(DN)MOVE(1000,State);
   // *************************************************
   // FAULTS
   15: NOP();
   // IF in the middle of a sequence AND the Drive Communications goes False, goto error state 910
   16: XIO(NTEC_Axis.StatDriveCommsOK)LIMIT(1,State,899)MOVE(910,State);
   // Fault State 910
   // Communications to the Drive was  lost during a sequence - Abort the sequence.
   17: EQ(State,910)OTL(ERR)MOVE(10,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the Drive Fault, goto error state 911
   18: XIC(NTEC_Axis.StatDriveFault)LIMIT(1,State,899)MOVE(911,State);
   // Fault State 910
   // Drive Fault during a sequence - Abort the sequence
   19: EQ(State,911)OTL(ERR)MOVE(11,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the QuickStop, goto error state 912
   20: XIC(NTEC_Axis.PDI_CMD.QuickStop)LIMIT(1,State,899)MOVE(912,State);
   // Fault State 912
   // Quick Stop during a sequence - Abort the sequence
   21: EQ(State,912)OTL(ERR)MOVE(12,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND Communications Command Error occurs, goto error state 913
   22: XIC(NTEC_Axis.CMD_ERR)LIMIT(1,State,899)MOVE(913,State);
   // Fault State 913
   // Communications Command Error during a sequence - Abort the sequence and issue a Quick Stop
   23: EQ(State,913)OTL(ERR)MOVE(13,ERR_Code)MOVE(999,State);
   // IF in the middle of a sequence AND the EnableIn goes False, goto error state 914
   24: XIO(Enable)LIMIT(1,State,899)MOVE(914,State);
   // Fault State 914
   // Enable Input changed to False / OFF during a sequence - Abort the sequence
   25: EQ(State,914)OTL(ERR)MOVE(14,ERR_Code)MOVE(999,State);
   // Fault State 920
   // Input Parameter Range Error
   26: EQ(State,920)OTL(ERR)MOVE(2,ERR_Code)MOVE(999,State);
   // Fault State - command error during sequence
   // IF in the middle of a sequence, this AOI receives a Command Error, goto error state 930
   27: XIC(NTEC_Axis.StatCommandError)LIMIT(100,State,899)MOVE(930,State);
   // Fault State 930
   // Command Error during a sequence - Abort the sequence
   28: EQ(State,930)OTL(ERR)MOVE(3,ERR_Code)MOVE(999,State);
   // Fault State 940
   // Timeout Fault - servo drive did not go OFF - Abort the sequence
   29: EQ(State,940)OTL(ERR)MOVE(4,ERR_Code)MOVE(999,State);
   // Fault State 999
   // Clear the outputs after a Fault
   30: EQ(State,999)[MOVE(0,NTEC_Axis.PDI_CMD.SetValue1) MOVE(0,NTEC_Axis.PDI_CMD.SetValue2) MOVE(0,NTEC_Axis.PDI_CMD.SetValue3) MOVE(0,NTEC_Axis.PDI_CMD.CMD) ,OTU(NTEC_Axis.PDI_CMD.Trig) MOVE(1000,State) ];
   // ********************************************************
   // State 1000
   // Wait for Enable In to go Off/On.  Just sit in this state until AOI triggered again.
   // Reset faults if the MAFT triggers a reset.  Reset if waiting is state 1000 OR state 0.
   31: [EQ(State,1000) ,EQ(State,0) ][NOP() ,XIC(NTEC_Axis.StatResettingFault) OTU(ERR) MOVE(0,ERR_Code) ];
END_ROUTINE
