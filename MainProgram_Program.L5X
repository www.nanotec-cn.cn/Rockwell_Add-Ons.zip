(* Logix 5000 Program export MainProgram; software revision 35.00; part 3 of 7 *)
(* tags used below, declared in another part *)
   DriveOutputData : SINT[128];   // Drive Output Data (128 Byte Array) DriveName:O1.Data
   OneShot : DINT;   // One Shots
   NewCmdAcceptedOneShot : BOOL;   // New command accepted by Drive
   Enable_Command : BOOL;   // Enable Command Send Sequence
   local_SetValue2 : INT;   // local use PDI Set Value 2
   local_SetValue3 : SINT;   // Local use PDI Set Value 3
   local_CMD : SINT;   // local use PDI Command Value
   local_SetValue1 : DINT;   // local use PDI Set Value 1
   const_zero_SINT : SINT;   // Zero SINT
   QuickStopAlreadyActive : BOOL;   // Quick Stop is already active
   tmr_ClearCmd : TIMER;   // Timer to Clear Command Register
   tmr_CmdAckTimeout3 : TIMER;   // Timer 3
   Delta : DINT;
   HighLimitTorqueWindow : DINT;
   LowLimitTorqueWindow : DINT;
   LimitsReadDone : BOOL;   // Done reading the limits from the drive, only one time at first scan
   QuckStopScan : BOOL;
   JogRunningTimer : TIMER;
   TorqueRunningTimer : TIMER;
   CmdDelayTmr3 : TIMER;
   JogStartingTimer : TIMER;
(* NTEC_Comms, continued *)

   // State 155
   // Profile Velocity (Jog and Stop) command: wait for the AtTarget to go off, as the Profile Velocity starts.
   49: XIC(Enable_Command)EQU(State,155)[XIO(NTEC_Axis.StatMotion_AtTarget) ,SUB(local_SetValue1,NTEC_Axis.PDI_Status.VelocityActualValue,Delta) LIM(NTEC_Axis.DriveLimits.VelocityWindowNeg,Delta,NTEC_Axis.DriveLimits.VelocityWindowPos) ,TON(JogStartingTimer,?,?) XIC(JogStartingTimer.DN) ]MOV(156,State);
   // State 156
   // Jog command: wait for the AtTarget to come back ON, as the Profile Velocity meets the target velocity.
   50: XIC(Enable_Command)EQU(State,156)[XIC(NTEC_Axis.StatMotion_AtTarget) ,SUB(local_SetValue1,NTEC_Axis.PDI_Status.VelocityActualValue,Delta) LIM(NTEC_Axis.DriveLimits.VelocityWindowNeg,Delta,NTEC_Axis.DriveLimits.VelocityWindowPos) ,TON(JogRunningTimer,?,?) XIC(JogRunningTimer.DN) ]MOV(160,State);
   // State 157
   // Torque command: wait for the AtTarget to go off, as the Profile Torque starts.
   51: XIC(Enable_Command)EQU(State,157)[XIO(NTEC_Axis.StatMotion_AtTarget) ,SUB(local_SetValue1,NTEC_Axis.PDI_Status.TorqueActualValue,Delta) LIM(LowLimitTorqueWindow,Delta,HighLimitTorqueWindow) ]MOV(158,State);
   // State 156
   // Torque command: wait for the AtTarget to come back ON, as the torque meets the target.
   52: XIC(Enable_Command)EQU(State,158)[XIC(NTEC_Axis.StatMotion_AtTarget) ,SUB(local_SetValue1,NTEC_Axis.PDI_Status.TorqueActualValue,Delta) LIM(LowLimitTorqueWindow,Delta,HighLimitTorqueWindow) ,TON(TorqueRunningTimer,?,?) XIC(TorqueRunningTimer.DN) ]MOV(160,State);
   // State 160
   //  Handshake back to command AOI by  setting the DN bit, and clearing the command registers.
   53: XIC(Enable_Command)EQU(State,160)[FLL(const_zero_SINT,DriveOutputData[0],8) ,CLR(local_SetValue1) CLR(local_SetValue2) CLR(local_SetValue3) CLR(local_CMD) ,CLR(NTEC_Axis.PDI_CMD.SetValue1) CLR(NTEC_Axis.PDI_CMD.SetValue2) CLR(NTEC_Axis.PDI_CMD.SetValue3) CLR(NTEC_Axis.PDI_CMD.CMD) ]OTL(NTEC_Axis.CMD_DN)MOV(170,State);
   // State 170
   // Wait for the CMD Trigger to be turned off by the AOI.
   54: XIC(Enable_Command)EQU(State,170)XIO(NTEC_Axis.PDI_CMD.Trig)MOV(180,State);
   // State 180
   //  Turn off the IP bit to complete the handskake.  The CMD_DN bit stays ON.
   55: XIC(Enable_Command)EQU(State,180)OTU(NTEC_Axis.CMD_IP)MOV(0,State);
   // **********************************************************************
   // QUICK STOP
   // COMMAND SEND TO DRIVE SEQUENCE
   // State 500
   // Verify the Drive's output word is not already set to the quick stop command (3).
   56: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,500)OTL(NTEC_Axis.PDI_CMD.QuickStop)OTL(NTEC_Axis.CMD_IP)OTU(NTEC_Axis.CMD_DN)[NEQ(DriveOutputData[7],0) OTE(QuickStopAlreadyActive) ,XIO(QuickStopAlreadyActive) MOV(520,State) ,XIC(QuickStopAlreadyActive) MOV(510,State) ,XIO(NTEC_Axis.StatServoActionStatus) MOV(555,State) ];
   // State 510
   // Clear the Drive's output command bytes
   57: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,510)FLL(const_zero_SINT,DriveOutputData[0],8)TON(tmr_ClearCmd,?,?)XIC(tmr_ClearCmd.DN)MOV(510,State);
   // State 520
   // Copy the command from the NTEC Axis tag (which came from an AOI) out to the Drive.
   //  The first "object" of the Ethernet IP interface is 4 Bytes (or one DINT).  This is "Set Value 1" for any command over ENET IP.
   // The second "object" is 2 bytes (or one INT).  This is "Set Value 2" for any command over ENET IP.
   // The third "object" is 1 byte (one SINT).  This is "Set Value 3" for any command over ENET IP.
   // The fourth and last "object" is one byte (one SINT).  This is the Command code over ENET IP.
   // All possible PDO commands are covered in Nanotec's Functional Description - Plug and Drive Interface document.
   58: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,520)CPS(const_zero_SINT,DriveOutputData[0],4)CPS(const_zero_SINT,DriveOutputData[4],2)CPS(const_zero_SINT,DriveOutputData[6],1)MOV(525,State);
   59: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,525)TON(CmdDelayTmr3,?,?)XIC(CmdDelayTmr3.DN)MOV(3,DriveOutputData[7])MOV(530,State);
   // State 130
   // Verify the Command Active bit status from Drive.
   60: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,530)[[XIC(NewCmdAcceptedOneShot) ,XIO(NTEC_Axis.StatServoActionStatus) ] MOV(540,State) ,XIC(NTEC_Axis.StatCommandError) MOV(930,State) ,TON(tmr_CmdAckTimeout3,?,?) XIC(tmr_CmdAckTimeout3.DN) MOV(940,State) ];
   // State 540
   // Clear the output registers.  Once the command is received by the drive, it will continue to execute that command until complete OR until another command comes in.
   61: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,540)FLL(const_zero_SINT,DriveOutputData[0],8)XIO(NTEC_Axis.StatNewCmdToggle)MOV(550,State);
   // State 550
   // Verify the Command completes successfully.
   // The Servo Action Status should be off, as the power to the motor should be OFF after a quick stop.
   62: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,550)[XIO(NTEC_Axis.StatServoActionStatus) MOV(560,State) ,XIC(NTEC_Axis.StatCommandError) MOV(930,State) ];
   // State 555
   // Allow one scan before resetting, to quick stop all command AOIs.
   63: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,555)[XIC(QuckStopScan) MOV(560,State) ,OTE(QuckStopScan) ];
   // State 560
   //  Handshake back to command AOI by setting the DN bit, and clearing the command registers.
   64: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,560)[CLR(local_SetValue1) CLR(local_SetValue2) CLR(local_SetValue3) CLR(local_CMD) ,CLR(NTEC_Axis.PDI_CMD.SetValue1) CLR(NTEC_Axis.PDI_CMD.SetValue2) CLR(NTEC_Axis.PDI_CMD.SetValue3) CLR(NTEC_Axis.PDI_CMD.CMD) ,OTU(NTEC_Axis.PDI_CMD.QuickStop) ]OTL(NTEC_Axis.CMD_DN)MOV(570,State);
   // State 570
   // Complete the Quick Stop sequence.
   // Wait for the CMD Trigger to be turned off by the commanding  AOI.
   65: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,570)XIO(NTEC_Axis.PDI_CMD.Trig)MOV(580,State);
   // State 580
   // Complete the Quick Stop sequence.
   // Turn off the IP bit to complete the handskake.  The CMD_DN bit stays ON.
   66: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,580)OTU(NTEC_Axis.CMD_IP)MOV(0,State);
   // *************************************************
   // FAULTS
   67: NOP();
   // Fault #1
   // IF in the middle of a sequence AND the EnableIn goes False, goto error state 910
   68: [XIC(NTEC_Axis.StatDriveFault) LIM(100,State,499) ,XIO(NTEC_Axis.StatDriveCommsOK) ONS(OneShot.4) ]MOV(910,State);
   // Fault #3
   // IF in the middle of a sequence, this AOI receives a Command Error, goto error state 930
   69: XIC(NTEC_Axis.StatCommandError)LIM(100,State,499)MOV(930,State);
   // Fault State 910
   // Enable Input changed to False / OFF during a sequence - Drive Faulted or Offline - Clear all and abort the sequence.
   70: EQU(State,910)OTL(NTEC_Axis.CMD_ERR)OTL(NTEC_Axis.PDI_CMD.QuickStop)OTL(ERR)MOV(1,ERR_Code)MOV(999,State);
   // Fault State 920
   // Input Parameter Range Error
   71: EQU(State,920)OTL(NTEC_Axis.CMD_ERR)OTL(ERR)MOV(2,ERR_Code)MOV(999,State);
   // Fault State 930
   // Command Error during a sequence - Abort the sequence
   72: EQU(State,930)OTL(NTEC_Axis.CMD_ERR)OTL(NTEC_Axis.PDI_CMD.QuickStop)OTL(ERR)MOV(3,ERR_Code)MOV(999,State);
   // Fault State 940
   // Command sent to Drive, but no ACK (command toggle bit) during a sequence - Abort the sequence
   73: EQU(State,940)OTL(NTEC_Axis.CMD_ERR)OTL(ERR)MOV(4,ERR_Code)MOV(999,State);
   // Fault State 950
   // Read Error - no response from the READ command
   74: EQU(State,950)OTL(NTEC_Axis.CMD_ERR)OTL(ERR)MOV(5,ERR_Code)MOV(999,State);
   // Fault State 960
   // Error during a sequence - Drive Inputs are not Zero -  Abort the sequence
   75: EQU(State,960)OTL(NTEC_Axis.CMD_ERR)OTL(NTEC_Axis.PDI_CMD.QuickStop)OTL(ERR)MOV(6,ERR_Code)MOV(999,State);
   // Fault State 970
   // Error during READ of the limits from the Drive -  Abort the sequence
   76: EQU(State,970)OTL(NTEC_Axis.CMD_ERR)OTL(ERR)MOV(7,ERR_Code)MOV(999,State);
   // Fault State 999
   // Clear data and exit
   77: EQU(State,999)[FLL(const_zero_SINT,DriveOutputData[0],8) ,CLR(local_SetValue1) CLR(local_SetValue2) CLR(local_SetValue3) CLR(local_CMD) ]OTU(NTEC_Axis.PDI_CMD.Trig)OTU(NTEC_Axis.CMD_IP)OTL(NTEC_Axis.CMD_DN)MOV(1000,State);
   // State 1000
   // Wait until command trigger is turned off by the originating AOI.
   // OR a command = 2 for Motion Axis Fault Reset
   78: EQU(State,1000)[XIO(NTEC_Axis.PDI_CMD.Trig) ,OTU(NTEC_Axis.StatResettingFault) EQU(NTEC_Axis.PDI_CMD.CMD,2) ]MOV(0,State);
END_ROUTINE

ROUTINE Postscan   (* ladder *)
   0: NOP();
END_ROUTINE

ROUTINE Prescan   (* ladder *)
   // ***
   // NTEC Communications Pre-Scan Routine
   // ***
   0: NOP();
   // First scan for this AOI, clear all of the registers.
   1: [OTU(ERR) OTU(NTEC_Axis.CMD_ERR) CLR(ERR_Code) ,CLR(State) FLL(const_zero_SINT,DriveOutputData[0],8) ,CLR(local_SetValue1) CLR(local_SetValue2) CLR(local_SetValue3) CLR(local_CMD) ,OTU(NTEC_Axis.PDI_CMD.Trig) OTU(NTEC_Axis.PDI_CMD.Halt) OTL(NTEC_Axis.PDI_CMD.QuickStop) CLR(NTEC_Axis.PDI_CMD.SetValue1) CLR(NTEC_Axis.PDI_CMD.SetValue2) CLR(NTEC_Axis.PDI_CMD.SetValue3) CLR(NTEC_Axis.PDI_CMD.CMD) ];
   2: CLR(OneShot);
   3: OTU(LimitsReadDone)OTU(NTEC_Axis.StatResettingFault)OTU(NTEC_Axis.CMD_DN)OTU(NTEC_Axis.CMD_IP);
END_ROUTINE
END_ADD_ON_INSTRUCTION

ADD_ON_INSTRUCTION NTEC_MAFR   (* revision 1.5, vendor Third Coast Automation, Nashville TN, ExecutePrescan, ExecuteEnableInFalse *)
// Motion Axis Fault Reset - This AOI sends a Reset Fault command to the Drive, and also resets Command Errors in any NTEC AOI.
// Revision note:
// Release Aug 27, 2024, update CPS instructions LEN
// Help:
// AOI written by:
// Tim Cochran
// Third Coast Automation
// Nashville, TN
// MAFR ERR_Codes:
// 2: Input parameter range error – review and fix input parameters.
// 3: Command Error response from the Drive after command sent.
// 10: Communications Failed to Drive.
// 11: Drive Fault during the Fault Reset sequence.
// 12: Quick Stop triggered by software outside of this AOI.
// 13: Command Error response from the Drive.
// 14: 1: Enable input changed to False during sequence due to Drive Fault or Offline.
VAR_IN_OUT
   NTEC_Axis : NTEC_Axis; {required}   // NTEC Axis Tag
END_VAR
VAR_OUTPUT
   EN : BOOL; {visible}   // Enabled
   DN : BOOL; {visible}   // Successfully Done
   ERR : BOOL; {visible}   // Instruction Error
   ERR_Code : DINT; {access Read Only, visible}   // Instruction Error Code
END_VAR
VAR
   State : DINT; {access None}
   Enable : BOOL; {access None}
   InputRangesOK : BOOL; {access None}
   tmr_Verify : TIMER := (PRE := 100); {access None}
END_VAR

ROUTINE EnableInFalse   (* ladder *)
// Enable In False Routine
   // ***
   // Enable In False Routine
   // Runs when the rung to ths AOI instance is False
   // ***
   0: NOP();
   1: XIC(NTEC_Axis.StatResettingFault)OTU(ERR)CLR(ERR_Code);
   2: XIC(EN)LIM(1,State,899)XIC(NTEC_Axis.PDI_CMD.Trig)MOV(0,NTEC_Axis.PDI_CMD.SetValue1)MOV(0,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)CLR(State);
END_ROUTINE

ROUTINE Logic   (* ladder *)
   // ***
   // Nanotec Motion Axis Fault Reset
   // ***
   0: NOP();
   // ***
   // Main Logic Routine
   // ***
   1: NOP();
   // If the Enable (EN) bit is not on yet, this is first scan, so unlatch the Done (DN) bit.
   2: XIO(EN)OTU(DN);
   // Latch Enable (EN) bit as long as this AOI is being executed.
   3: XIC(EnableIn)OTE(EN);
   // Enable the State Machine Sequence
   4: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)XIO(NTEC_Axis.PDI_CMD.QuickStop)OTE(Enable);
   // Step 0
   // Start the Sequence
   5: XIC(Enable)EQU(State,0)XIO(NTEC_Axis.PDI_CMD.Trig)XIO(NTEC_Axis.CMD_IP)MOV(100,State);
   // State 100
   // Clear this AOI's fault tags
   6: XIC(Enable)EQU(State,100)OTU(ERR)CLR(ERR_Code)MOV(110,State);
   // State 110
   7: XIC(Enable)EQU(State,110)MOV(120,State);
   // State 120
   // Load the parameters and command to send to the NTEC_Comms AOI.
   8: XIC(Enable)EQU(State,120)MOV(0,NTEC_Axis.PDI_CMD.SetValue1)MOV(0,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(2,NTEC_Axis.PDI_CMD.CMD)MOV(130,State);
   // State 130
   // Trigger the Command.
   9: XIC(Enable)EQU(State,130)OTL(NTEC_Axis.PDI_CMD.Trig)MOV(150,State);
   // State 150
   // Verify the NTEC_Comms is In-Process (IP) sending the command to the Drive.
   10: XIC(Enable)EQU(State,150)XIC(NTEC_Axis.CMD_IP)MOV(155,State);
   // State 155
   // Time delay to allow faults to be reset.
   11: XIC(Enable)EQU(State,155)TON(tmr_Verify,?,?)XIC(tmr_Verify.DN)MOV(160,State);
   // State 160
   // Verify the NTEC_Comms is Done (DN) sending the command.
   12: XIC(Enable)EQU(State,160)XIC(NTEC_Axis.CMD_DN)MOV(170,State);
   // State 170
   // To finish the handshake with NTEC_Comms, this AOI clears the CMD_Trg and the NTEC_Comms clears its IP bit.
   13: XIC(Enable)EQU(State,170)MOV(0,NTEC_Axis.PDI_CMD.SetValue1)MOV(0,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig)MOV(180,State);
   // State 180
   // To finish the handshake with NTEC_Comms, the NTEC_Comms clears its IP bit.
   14: XIC(Enable)EQU(State,180)XIO(NTEC_Axis.CMD_IP)MOV(190,State);
   // State 190
   // Set the Done Bit
   // Move State to 1000, which is a rest state unitl the rung into this AOI is false.
   // END OF COMMAND SEQUENCE
   15: XIC(Enable)EQU(State,190)OTL(DN)MOV(1000,State);
   // *************************************************
   // FAULTS
   16: NOP();
   // IF in the middle of a sequence AND the Drive Communications goes False, goto error state 910
   17: XIO(NTEC_Axis.StatDriveCommsOK)LIM(160,State,899)MOV(910,State);
   // Fault State 910
   // Communications to the Drive was  lost during a sequence - Abort the sequence.
   18: EQU(State,910)OTL(ERR)MOV(10,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the Drive Fault, goto error state 911
   19: XIC(NTEC_Axis.StatDriveFault)LIM(160,State,899)MOV(911,State);
   // Fault State 910
   // Drive Fault during a sequence - Abort the sequence
   20: EQU(State,911)OTL(ERR)MOV(11,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the QuickStop, goto error state 912
   21: XIC(NTEC_Axis.PDI_CMD.QuickStop)LIM(1,State,899)MOV(912,State);
   // Fault State 912
   // Quick Stop during a sequence - Abort the sequence
   22: EQU(State,912)OTL(ERR)MOV(12,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND Communications Command Error occurs, goto error state 913
   23: XIC(NTEC_Axis.CMD_ERR)LIM(160,State,899)MOV(913,State);
   // Fault State 913
   // Communications Command Error during a sequence - Abort the sequence and issue a Quick Stop
   24: EQU(State,913)OTL(ERR)MOV(13,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the EnableIn goes False, goto error state 914
   25: XIO(Enable)LIM(1,State,899)MOV(914,State);
   // Fault State 914
   // Enable Input changed to False / OFF during a sequence - Abort the sequence
   26: EQU(State,914)OTL(ERR)MOV(14,ERR_Code)MOV(999,State);
   // Fault State 920
   // Input Parameter Range Error
   27: EQU(State,920)OTL(ERR)MOV(2,ERR_Code)MOV(999,State);
   // Fault State - command error during sequence
   // IF in the middle of a sequence, this AOI receives a Command Error, goto error state 930
   28: XIC(NTEC_Axis.StatCommandError)LIM(160,State,899)MOV(930,State);
   // Fault State 930
   // Command Error during a sequence - Abort the sequence
   29: EQU(State,930)OTL(ERR)MOV(3,ERR_Code)MOV(999,State);
   // Fault State 999
   // Clear the outputs after a Fault
   30: EQU(State,999)[MOV(0,NTEC_Axis.PDI_CMD.SetValue1) MOV(0,NTEC_Axis.PDI_CMD.SetValue2) MOV(0,NTEC_Axis.PDI_CMD.SetValue3) MOV(0,NTEC_Axis.PDI_CMD.CMD) ,OTU(NTEC_Axis.PDI_CMD.Trig) MOV(1000,State) ];
   // ********************************************************
   // State 1000
   // Wait for Enable In to go Off/On.  Just sit in this state until AOI triggered again.
   31: EQU(State,1000)NOP();
END_ROUTINE
