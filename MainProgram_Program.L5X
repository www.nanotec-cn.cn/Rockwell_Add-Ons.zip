(* Logix 5000 Program export MainProgram; software revision 35.00; part 2 of 7 *)
(* tags used below, declared in another part *)
   DN : BOOL;   // Successfully Done
   Enable : BOOL;
(* NTEC_VerifyLimits, continued *)

   // IF in the middle of a sequence AND the Drive Communications goes False, goto error state 910
   32: XIO(NTEC_Axis.StatDriveCommsOK)LIM(1,State,899)MOV(910,State);
   // Fault State 910
   // Communications to the Drive was  lost during a sequence - Abort the sequence.
   33: EQU(State,910)OTL(ERR)MOV(10,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the Drive Fault, goto error state 911
   34: XIC(NTEC_Axis.StatDriveFault)LIM(1,State,899)MOV(911,State);
   // Fault State 910
   // Drive Fault during a sequence - Abort the sequence
   35: EQU(State,911)OTL(ERR)MOV(11,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the QuickStop, goto error state 912
   36: XIC(NTEC_Axis.PDI_CMD.QuickStop)LIM(1,State,899)MOV(912,State);
   // Fault State 912
   // Quick Stop during a sequence - Abort the sequence
   37: EQU(State,912)OTL(ERR)MOV(12,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND Communications Command Error occurs, goto error state 913
   38: XIC(NTEC_Axis.CMD_ERR)LIM(1,State,899)MOV(913,State);
   // Fault State 913
   // Communications Command Error during a sequence - Abort the sequence and issue a Quick Stop
   39: EQU(State,913)OTL(ERR)MOV(13,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the EnableIn goes False, goto error state 914
   40: XIO(Enable)LIM(1,State,899)MOV(914,State);
   // Fault State 914
   // Enable Input changed to False / OFF during a sequence - Abort the sequence
   41: EQU(State,914)OTL(ERR)MOV(14,ERR_Code)MOV(999,State);
   // Fault State 920
   // Input Parameter Range Error
   42: EQU(State,920)OTL(ERR)MOV(2,ERR_Code)MOV(999,State);
   // Fault State - command error during sequence
   // IF in the middle of a sequence, this AOI receives a Command Error, goto error state 930
   43: XIC(NTEC_Axis.StatCommandError)LIM(100,State,899)MOV(930,State);
   // Fault State 930
   // Command Error during a sequence - Abort the sequence
   44: EQU(State,930)OTL(ERR)MOV(3,ERR_Code)MOV(999,State);
   // Fault State 970
   // Error during READ of the limits from the Drive -  Abort the sequence
   45: EQU(State,970)OTL(ERR)MOV(999,State);
   // Fault State 999
   // Clear the outputs after a Fault
   46: EQU(State,999)[MOV(0,NTEC_Axis.PDI_CMD.SetValue1) MOV(0,NTEC_Axis.PDI_CMD.SetValue2) MOV(0,NTEC_Axis.PDI_CMD.SetValue3) MOV(0,NTEC_Axis.PDI_CMD.CMD) ,OTU(NTEC_Axis.PDI_CMD.Trig) MOV(1000,State) ];
   // ********************************************************
   // State 1000
   // Wait for Enable In to go Off/On.  Just sit in this state until AOI triggered again.
   // Reset faults if the MAFT triggers a reset.  Reset if waiting is state 1000 OR state 0.
   47: [EQU(State,1000) ,EQU(State,0) ][NOP() ,XIC(NTEC_Axis.StatResettingFault) OTU(ERR) MOV(0,ERR_Code) ];
END_ROUTINE

ROUTINE Postscan   (* ladder *)
// Home Post-Scan Routine
   // ***
   // POST SCAN ROUTINE
   // ***
   0: NOP();
   // ***
   // POST-SCAN ROUTINE
   // ***
   1: OTU(NTEC_Axis.PDI_CMD.Trig)NOP();
   2: OTU(EN);
END_ROUTINE

ROUTINE Prescan   (* ladder *)
// Home Pre-Scan Routine
   // ***
   // PRESCAN ROUTINE
   // ***
   0: NOP();
   1: OTU(ERR)CLR(ERR_Code);
   2: LIM(1,State,899)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(DN)OTU(EN)CLR(State);
END_ROUTINE
END_ADD_ON_INSTRUCTION

ADD_ON_INSTRUCTION NTEC_Comms   (* revision 1.5, ExecutePrescan, ExecuteEnableInFalse *)
// AOI to control the communications to one Plug and Drive system.
// Revision note:
// Release Aug 27, 2024, update CPS instructions LEN
// Help:
// AOI written by:
// Tim Cochran
// Third Coast Automation
// Nashville, TN
// Comms ERR_Codes:
// 1: Enable input changed to False during sequence due to Drive Fault or Offline.
// 2: Input parameter range error – review and fix input parameters.
// 3: Command Error response from the Drive.
// 4: Command timeout – no acknowledge from the Drive after command was sent.
// 5: Read Error – no value sent from Drive after Read command.
// 6: Programming error – Drive outputs for PDI Command not zero at start of new command.
// 7: Error reading the preset limits from the Drive: Position, Velocity, Accel, Decel, Torque limits.
VAR_IN_OUT
   NTEC_Axis : NTEC_Axis; {required}
   DriveInputData : SINT[128]; {required}   // Drive Input Data (128 Byte Array) DriveName:I1.Data
   DriveOutputData : SINT[128]; {required}   // Drive Output Data (128 Byte Array) DriveName:O1.Data
END_VAR
VAR_INPUT
   ConnectionFaulted : BOOL; {required}   // DriveName:I1.Connection Faulted
END_VAR
VAR_OUTPUT
   EN : BOOL; {visible}   // AOI Enabled
   ERR : BOOL; {visible}   // Error Status
   ERR_Code : DINT; {visible}   // Error Code
END_VAR
VAR
   State : DINT; {access None}   // State Value
   OneShot : DINT; {access None}   // One Shots
   NewCmdAcceptedOneShot : BOOL; {access None}   // New command accepted by Drive
   Enable_Command : BOOL; {access None}   // Enable Command Send Sequence
   local_SetValue2 : INT; {access None}   // local use PDI Set Value 2
   local_SetValue3 : SINT; {access None}   // Local use PDI Set Value 3
   local_CMD : SINT; {access None}   // local use PDI Command Value
   local_SetValue1 : DINT; {access None}   // local use PDI Set Value 1
   tmr_CmdAckTimeout : TIMER := (PRE := 100); {access None}   // Timer 1
   const_zero_SINT : SINT; {access None}   // Zero SINT
   const_two_SINT : SINT; {access None}
   QuickStopAlreadyActive : BOOL; {access None}   // Quick Stop is already active
   tmr_ClearCmd : TIMER := (PRE := 20); {access None}   // Timer to Clear Command Register
   tmr_CmdAckTimeout3 : TIMER := (PRE := 50); {access None}   // Timer 3
   always_off : BOOL; {access None}
   tmr_CmdAckTimeout2 : TIMER := (PRE := 300); {access None}   // Timer 2
   NoActiveCommand_Comms : BOOL; {access None}   // No commands are currently active
   InputRangesOK_Comms : BOOL; {access None}   // Input Ranges OK
   StartingPosition : DINT; {access None}
   Delta : DINT; {access None}
   HighLimitPositionWindow : DINT := 100; {access None}
   LowLimitPositionWindow : DINT := -100; {access None}
   HighLimitVelocityWindow : DINT := 100; {access None}
   LowLimitVelocityWindow : DINT := -100; {access None}
   EndPosition : DINT; {access None}
   HighLimitTorqueWindow : DINT := 100; {access None}
   LowLimitTorqueWindow : DINT := -100; {access None}
   tmr_VerifyHomedInput : TIMER := (PRE := 2000); {access None}
   ServoActionWatchdog : TIMER := (PRE := 1000); {access None}
   CmdDelayTmr1 : TIMER := (PRE := 20); {access None}
   LimitsReadDone : BOOL; {access None}   // Done reading the limits from the drive, only one time at first scan
   cntrl_ReadLimits1 : NTEC_READ; {access None}
   ReadLimit1 : DINT; {access None}
   cntrl_ReadLimits2 : NTEC_READ; {access None}
   cntrl_ReadLimits3 : NTEC_READ; {access None}
   cntrl_ReadLimits4 : NTEC_READ; {access None}
   cntrl_ReadLimits5 : NTEC_READ; {access None}
   cntrl_ReadLimits6 : NTEC_READ; {access None}
   cntrl_ReadLimits7 : NTEC_READ; {access None}
   cntrl_ReadLimits8 : NTEC_READ; {access None}
   cntrl_ReadLimits9 : NTEC_READ; {access None}
   cntrl_ReadLimits10 : NTEC_READ; {access None}
   cntrl_ReadLimits11 : NTEC_READ; {access None}
   cntrl_ReadLimits12 : NTEC_READ; {access None}
   DriveCommsWarmupDelay : TIMER := (PRE := 2000); {access None}
   StateReadLimits : DINT; {access None}
   QuckStopScan : BOOL; {access None}
   ReadResponseTimer : TIMER := (PRE := 100); {access None}
   cntrl_ReadLimits : NTEC_VerifyLimits; {access None}
   ReadLimitErrTmr : TIMER := (PRE := 200); {access None}
   JogRunningTimer : TIMER := (PRE := 20); {access None}
   TorqueRunningTimer : TIMER := (PRE := 20); {access None}
   cntrl_ReadErrorCode1 : NTEC_READ; {access None}
   ErrorCode : DINT; {access None}
   cntrl_ReadErrorCode2 : NTEC_READ; {access None}
   CmdDelayTmr2 : TIMER := (PRE := 20); {access None}
   CmdDelayTmr3 : TIMER := (PRE := 20); {access None}
   JogStartingTimer : TIMER; {access None}
END_VAR

ROUTINE EnableInFalse   (* ladder *)
// Close out routine
   // Need to clear ONS and others?
   0: NOP();
   // First scan for this AOI, clear all of the registers.
   1: [OTU(ERR) CLR(ERR_Code) ,CLR(State) FLL(const_zero_SINT,DriveOutputData[0],8) ,CLR(local_SetValue1) CLR(local_SetValue2) CLR(local_SetValue3) CLR(local_CMD) ,OTU(NTEC_Axis.PDI_CMD.Trig) OTU(NTEC_Axis.PDI_CMD.Halt) OTL(NTEC_Axis.PDI_CMD.QuickStop) CLR(NTEC_Axis.PDI_CMD.SetValue1) CLR(NTEC_Axis.PDI_CMD.SetValue2) CLR(NTEC_Axis.PDI_CMD.SetValue3) CLR(NTEC_Axis.PDI_CMD.CMD) ];
   2: CLR(OneShot);
   3: OTU(LimitsReadDone)OTU(NTEC_Axis.StatResettingFault)OTU(NTEC_Axis.CMD_DN)OTU(NTEC_Axis.CMD_IP);
END_ROUTINE

ROUTINE Logic   (* ladder *)
   // ***
   // NTEC Communications
   // Main Logic Routine
   // ***
   0: NOP();
   // Move all of the input Status bytes from the Nanotec Drive back to the PLC:
   // The first "object" of the Ethernet IP interface is two bytes (one INT).  This byte contains the "Status" of the drive as a bit mask.  Each bit is assigned a meaning.
   // The second "object" is 2 bytes (INT) for the Error Code
   // The third object is  four bytes (one DINT).  This contains the "Return Value" based on the last/current command or operating mode.  (i.e. when in Profile Position this is the actual position value).
   1: CPS(DriveInputData[0],NTEC_Axis.PDI_Status.Status,1)CPS(DriveInputData[2],NTEC_Axis.PDI_Status.ErrorCode,1)CPS(DriveInputData[4],NTEC_Axis.PDI_Status.ReturnValue,1);
   2: CPS(DriveInputData[8],NTEC_Axis.PDI_Status.PositionActualValue,1)CPS(DriveInputData[12],NTEC_Axis.PDI_Status.VelocityActualValue,1)CPS(DriveInputData[16],NTEC_Axis.PDI_Status.DigitalInputs,1);
   3: CPS(DriveInputData[20],NTEC_Axis.PDI_Status.TorqueActualValue,1)CPS(DriveInputData[22],NTEC_Axis.PDI_Status.AnalogInput1,1)CPS(DriveInputData[24],NTEC_Axis.PDI_Status.FollowingError,1)CPS(DriveInputData[28],NTEC_Axis.PDI_Status.NanoJ_Output1,1);
   // Parse out the Status INT to recognizable bits tagnames
   // Bit 0 - Operation Enabled (drive is energised)
   // Bit 1 - Warning (warnings are in 603F:00)
   // Bit 2 - Fault, Drive is in Error (Faults are in 603F:00)
   // Bit 3 - Target Reached (bit is set when targe position is reached)
   // Bit 4 -  Following Error (bit is set when following error detected, per values configured in the drive using Nanotec Plug and Drive software)
   // Bit 5 - Limit Reached (this bit is set if a limit (position, speed, etc.) is exceeded
   // Bit 6 - N/A
   // Bit 7 - Halt Bit (set when quick stop active or halt bit was set)
   // Bit 11 - Homing Done
   // Bit 12 - Auto Setup Done
   // Bit 14 - Toggle Command (bit is set if a new command is detected)
   // Bit 15 - Command Error (bit is set if error occured when executing a command.  Error code is in the status Return Value over ENET IP)
   4: XIO(ConnectionFaulted)OTE(NTEC_Axis.StatDriveCommsOK);
   5: XIC(NTEC_Axis.PDI_Status.Status.0)OTE(NTEC_Axis.StatServoActionStatus);
   6: XIC(NTEC_Axis.PDI_Status.Status.1)OTE(NTEC_Axis.StatDriveWarning);
   7: XIC(NTEC_Axis.PDI_Status.Status.2)OTE(NTEC_Axis.StatDriveFault);
   8: XIC(NTEC_Axis.PDI_Status.Status.3)OTE(NTEC_Axis.StatMotion_AtTarget);
   9: XIC(NTEC_Axis.PDI_Status.Status.4)OTE(NTEC_Axis.StatMotion_FollowingError);
   10: XIC(NTEC_Axis.PDI_Status.Status.5)OTE(NTEC_Axis.StatMotion_LimitExceeded);
   11: XIC(NTEC_Axis.PDI_Status.Status.7)OTE(NTEC_Axis.StatMotion_Halt);
   12: XIC(NTEC_Axis.PDI_Status.Status.11)OTE(NTEC_Axis.StatMotion_Homed);
   13: XIC(NTEC_Axis.PDI_Status.Status.14)OTE(NTEC_Axis.StatNewCmdToggle);
   14: [XIC(NTEC_Axis.StatNewCmdToggle) ONS(OneShot.1) ,XIO(NTEC_Axis.StatNewCmdToggle) ONS(OneShot.2) ]OTE(NewCmdAcceptedOneShot);
   15: XIC(NTEC_Axis.PDI_Status.Status.15)[OTE(NTEC_Axis.StatCommandError) ,ONS(OneShot.3) CPS(DriveInputData[4],NTEC_Axis.StatCommandErrorCode,1) ];
   // Setup the "constants" for use in the code.
   16: MOV(0,const_zero_SINT)MOV(2,const_two_SINT);
   // IF A WARNING or  FAULT, THEN MUST READ THE CODE OUT OF 0603f:00
   17: XIC(EnableIn)XIC(NTEC_Axis.StatDriveWarning)XIO(NTEC_Axis.StatResettingFault)[ONS(OneShot.5) XIO(cntrl_ReadErrorCode1.EN) ,XIC(cntrl_ReadErrorCode1.EN) XIO(cntrl_ReadErrorCode1.DN) ]XIC(NTEC_Axis.StatDriveCommsOK)NTEC_READ(cntrl_ReadErrorCode1,NTEC_Axis,16#603F,0)MOV(cntrl_ReadErrorCode1.Read_Value,NTEC_Axis.StatDriveWarningCode);
   // IF A WARNING or  FAULT, THEN MUST READ THE CODE OUT OF 0603f:00
   18: XIC(EnableIn)XIC(NTEC_Axis.StatDriveFault)XIO(NTEC_Axis.StatResettingFault)[ONS(OneShot.6) XIO(cntrl_ReadErrorCode2.EN) ,XIC(cntrl_ReadErrorCode2.EN) XIO(cntrl_ReadErrorCode2.DN) ]XIC(NTEC_Axis.StatDriveCommsOK)NTEC_READ(cntrl_ReadErrorCode2,NTEC_Axis,16#603F,0)MOV(cntrl_ReadErrorCode2.Read_Value,NTEC_Axis.StatDriveFaultCode);
   // ***********************************************************
   // COMMANDS
   // When the CMD_TRIG is set, verify the command values are inside the valid range and send to the Drive.
   // ***********************************************************
   19: XIC(EnableIn)OTE(EN);
   // ENABLE all of the logic in the Command sequence here  IF communications to the Drive is OK, and the Drive is not faulted..
   20: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)XIO(NTEC_Axis.StatDriveFault)OTE(Enable_Command);
   // CLEAR FAULT TRIGGER RECEIVED
   // This is a special case trigger, with its own sequence, to clear all faults.
   21: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,0)XIC(NTEC_Axis.PDI_CMD.Trig)EQU(NTEC_Axis.PDI_CMD.CMD,2)MOV(10,State);
   // STANDARD AOI COMMAND RECEIVED
   // Copy the command data into internal registers to be used within this AOI.
   // If the Fault Reset command 2 is sent, clear the internal error bits and attempt to send the Fault Reset to the Drive.
   22: XIC(EnableIn)XIC(Enable_Command)EQU(State,0)[XIC(LimitsReadDone) ,EQU(NTEC_Axis.PDI_CMD.CMD,14) ]XIC(NTEC_Axis.PDI_CMD.Trig)MOV(100,State);
   // QUICK STOP TRIGGER RECEIVED
   // This is a special case trigger, with its own sequence, to clear command an immediate Quick Stop.
   23: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)LIM(599,State,500)[XIC(NTEC_Axis.PDI_CMD.Trig) EQU(NTEC_Axis.PDI_CMD.CMD,3) ,XIC(NTEC_Axis.PDI_CMD.QuickStop) ]MOV(500,State);
   // First Scan - Read the Limits from the Drive
   24: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)XIO(LimitsReadDone)[NTEC_VerifyLimits(cntrl_ReadLimits,NTEC_Axis) ,XIC(cntrl_ReadLimits.EN) XIC(cntrl_ReadLimits.DN) OTL(LimitsReadDone) ,XIO(LimitsReadDone) XIC(cntrl_ReadLimits.ERR) XIO(ERR) EQU(ERR_Code,0) EQU(State,0) TON(ReadLimitErrTmr,?,?) XIC(ReadLimitErrTmr.DN) OTL(ERR) MOV(970,ERR_Code) ];
   // ********************************************************************************************************************************
   // CLEAR FAULT COMMAND TO DRIVE SEQUENCE STATE MACHINE
   // State 10
   25: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,10)CLR(NTEC_Axis.StatDriveFaultCode)CLR(NTEC_Axis.StatDriveWarningCode)OTU(NTEC_Axis.CMD_ERR)OTU(ERR)CLR(ERR_Code)OTL(NTEC_Axis.CMD_IP)OTU(NTEC_Axis.CMD_DN)OTL(NTEC_Axis.StatResettingFault)MOV(20,State);
   // State 20
   // Copy the command from the NTEC Axis tag (which came from an AOI) out to the Drive.
   //  The first "object" of the Ethernet IP interface is 4 Bytes (or one DINT).  This is "Set Value 1" for any command over ENET IP.
   // The second "object" is 2 bytes (or one INT).  This is "Set Value 2" for any command over ENET IP.
   // The third "object" is 1 byte (one SINT).  This is "Set Value 3" for any command over ENET IP.
   // The fourth and last "object" is one byte (one SINT).  This is the Command code over ENET IP.
   // All possible PDO commands are covered in Nanotec's Functional Description - Plug and Drive Interface document.
   26: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,20)CPS(const_zero_SINT,DriveOutputData[0],4)CPS(const_zero_SINT,DriveOutputData[4],2)CPS(const_zero_SINT,DriveOutputData[6],1)MOV(25,State);
   27: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,25)TON(CmdDelayTmr1,?,?)XIC(CmdDelayTmr1.DN)CPS(const_two_SINT,DriveOutputData[7],1)MOV(30,State);
   // State 30
   // Verify the Command Active bit status from Drive.
   28: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,30)[XIC(NewCmdAcceptedOneShot) MOV(40,State) ,XIC(NTEC_Axis.StatCommandError) MOV(930,State) ,TON(tmr_CmdAckTimeout,?,?) XIC(tmr_CmdAckTimeout.DN) MOV(940,State) ];
   // State 40
   // Clear the output registers.  Once the command is received by the drive, it will continue to execute that command until complete OR until another command comes in.
   29: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,40)FLL(const_zero_SINT,DriveOutputData[0],8)XIO(NTEC_Axis.StatNewCmdToggle)MOV(50,State);
   // State 50
   //  Clear Fault Codes
   30: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,50)CLR(NTEC_Axis.StatCommandErrorCode)CLR(NTEC_Axis.StatDriveFaultCode)CLR(NTEC_Axis.StatDriveWarningCode)MOV(60,State);
   // State 60
   //  Handshake back to command AOI by setting the DN bit, and clearing the command registers.
   31: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,60)[CLR(local_SetValue1) CLR(local_SetValue2) CLR(local_SetValue3) CLR(local_CMD) ,CLR(NTEC_Axis.PDI_CMD.SetValue1) CLR(NTEC_Axis.PDI_CMD.SetValue2) CLR(NTEC_Axis.PDI_CMD.SetValue3) CLR(NTEC_Axis.PDI_CMD.CMD) ]OTL(NTEC_Axis.CMD_DN)MOV(70,State);
   // State 70
   // Wait for the CMD Trigger to be turned off by the AOI.
   32: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,70)XIO(NTEC_Axis.PDI_CMD.Trig)MOV(80,State);
   // State 80
   //  Turn off the IP bit to complete the handskake.  The CMD_DN bit stays ON.
   33: XIC(NTEC_Axis.StatDriveCommsOK)EQU(State,80)OTU(NTEC_Axis.StatResettingFault)OTU(NTEC_Axis.CMD_IP)MOV(0,State);
   // **********************************************************************
   // STANDARD COMMAND SEND TO DRIVE SEQUENCE
   // State 100
   // Verify input values are within acceptable ranges
   34: XIC(Enable_Command)EQU(State,100)CPS(NTEC_Axis.PDI_CMD.SetValue1,local_SetValue1,1)CPS(NTEC_Axis.PDI_CMD.SetValue2,local_SetValue2,1)CPS(NTEC_Axis.PDI_CMD.SetValue3,local_SetValue3,1)CPS(NTEC_Axis.PDI_CMD.CMD,local_CMD,1)OTL(NTEC_Axis.CMD_IP)OTU(NTEC_Axis.CMD_DN)[LIM(1,local_CMD,64) OTE(InputRangesOK_Comms) ,XIC(InputRangesOK_Comms) MOV(110,State) ,XIO(InputRangesOK_Comms) MOV(920,State) ];
   // State 110
   // Verify that there is no command currently accepted by the drive, so ready for a new command.
   35: XIC(Enable_Command)EQU(State,110)[EQU(DriveOutputData[0],0) EQU(DriveOutputData[1],0) EQU(DriveOutputData[2],0) EQU(DriveOutputData[3],0) EQU(DriveOutputData[4],0) EQU(DriveOutputData[5],0) EQU(DriveOutputData[6],0) EQU(DriveOutputData[7],0) XIO(NTEC_Axis.StatCommandError) OTE(NoActiveCommand_Comms) ,XIC(NoActiveCommand_Comms) MOV(120,State) ,XIO(NoActiveCommand_Comms) MOV(960,State) ];
   // State 120
   // Copy the command from the NTEC Axis tag (which came from an AOI) out to the Drive.
   //  The first "object" of the Ethernet IP interface is 4 Bytes (or one DINT).  This is "Set Value 1" for any command over ENET IP.
   // The second "object" is 2 bytes (or one INT).  This is "Set Value 2" for any command over ENET IP.
   // The third "object" is 1 byte (one SINT).  This is "Set Value 3" for any command over ENET IP.
   // The fourth and last "object" is one byte (one SINT).  This is the Command code over ENET IP.
   // All possible PDO commands are covered in Nanotec's Functional Description - Plug and Drive Interface document.
   36: XIC(Enable_Command)EQU(State,120)[CPS(local_SetValue1,DriveOutputData[0],4) CPS(local_SetValue2,DriveOutputData[4],2) CPS(local_SetValue3,DriveOutputData[6],1) MOV(125,State) ,MOV(NTEC_Axis.PDI_Status.PositionActualValue,StartingPosition) ];
   37: XIC(Enable_Command)EQU(State,125)TON(CmdDelayTmr2,?,?)XIC(CmdDelayTmr2.DN)CPS(local_CMD,DriveOutputData[7],1)MOV(130,State);
   // State 130
   // Verify the Command Active bit status from Drive.
   38: XIC(Enable_Command)EQU(State,130)[XIC(NTEC_Axis.StatNewCmdToggle) MOV(140,State) ,XIC(NTEC_Axis.StatCommandError) MOV(930,State) ,TON(tmr_CmdAckTimeout2,?,?) XIC(tmr_CmdAckTimeout2.DN) MOV(940,State) ];
   // State 140
   // Clear the output registers.  Once the command is received by the drive, it will continue to execute that command until complete OR until another command comes in.
   39: XIC(Enable_Command)EQU(State,140)XIO(NewCmdAcceptedOneShot)[EQU(local_CMD,14) MOV(141,State) ,NEQ(local_CMD,14) MOV(142,State) ];
   // State 141
   // Read command: wait for the Response, copy to the register.
   40: XIC(Enable_Command)EQU(State,141)[NEQ(NTEC_Axis.PDI_Status.ReturnValue,0) MOV(NTEC_Axis.PDI_Status.ReturnValue,NTEC_Axis.StatReadResponse) ,TON(ReadResponseTimer,?,?) XIC(ReadResponseTimer.DN) ]MOV(142,State);
   // State 142
   // Clear the output registers.  Once the command is received by the drive, it will continue to execute that command until complete OR until another command comes in.
   41: XIC(Enable_Command)EQU(State,142)FLL(const_zero_SINT,DriveOutputData[0],8)XIO(NTEC_Axis.StatNewCmdToggle)MOV(145,State);
   // State 145
   // Commands:
   //  1=OFF, 2=Clear Err, 3= Quickstop, 14=Read, 15=Write, 16=AutoSetup (N/A), 17=Imm Home, 18=Home, 20=Abs Move, 21=Inc Move, 23=Jog (Velocity Move), 25=Torque, Bit 6=Halt, Bit 7=ToggleCmd
   42: XIC(Enable_Command)EQU(State,145)[EQU(local_CMD,18) MOV(146,State) ,EQU(local_CMD,20) MOV(151,State) ,EQU(local_CMD,21) MOV(153,State) ,EQU(local_CMD,23) MOV(155,State) ,EQU(local_CMD,25) MOV(157,State) ,EQU(State,145) MOV(160,State) ];
   // State 146
   // Verify the Homed status goes off.
   43: XIC(Enable_Command)EQU(State,146)[XIO(NTEC_Axis.StatMotion_AtTarget) MOV(147,State) ,TON(tmr_VerifyHomedInput,?,?) XIC(tmr_VerifyHomedInput.DN) MOV(950,State) ];
   // State 147
   // Verify the Homed is returned from the Drive.
   // IF the Servo Action status is not ON after Watchdog time delay, Error.  (All Home commands, even immediate home, turn the motor ON)
   44: XIC(Enable_Command)EQU(State,147)[XIC(NTEC_Axis.StatMotion_AtTarget) MOV(160,State) ,XIO(NTEC_Axis.StatServoActionStatus) TON(ServoActionWatchdog,?,?) XIC(ServoActionWatchdog.DN) MOV(950,State) ];
   // State 151
   // Absolute Move command: wait for the AtTarget to go off, as the move starts.
   45: XIC(Enable_Command)EQU(State,151)[XIO(NTEC_Axis.StatMotion_AtTarget) ,SUB(local_SetValue1,StartingPosition,Delta) LIM(NTEC_Axis.DriveLimits.PositionWindowNeg,Delta,NTEC_Axis.DriveLimits.PositionWindowPos) ,SUB(local_SetValue1,NTEC_Axis.PDI_Status.PositionActualValue,Delta) LIM(NTEC_Axis.DriveLimits.PositionWindowNeg,Delta,NTEC_Axis.DriveLimits.PositionWindowPos) ]MOV(152,State);
   // State 152
   // Absolute Move command: wait for the AtTarget to come back ON, as the move completes.
   46: XIC(Enable_Command)EQU(State,152)[XIC(NTEC_Axis.StatMotion_AtTarget) ,SUB(local_SetValue1,NTEC_Axis.PDI_Status.PositionActualValue,Delta) LIM(NTEC_Axis.DriveLimits.PositionWindowNeg,Delta,NTEC_Axis.DriveLimits.PositionWindowPos) ]MOV(160,State);
   // State 153
   // Incremental Move command: wait for the AtTarget to go off, as the move starts.
   47: XIC(Enable_Command)EQU(State,153)[XIO(NTEC_Axis.StatMotion_AtTarget) ,ADD(local_SetValue1,StartingPosition,EndPosition) SUB(NTEC_Axis.PDI_Status.PositionActualValue,EndPosition,Delta) LIM(NTEC_Axis.DriveLimits.PositionWindowNeg,Delta,NTEC_Axis.DriveLimits.PositionWindowPos) ,LIM(NTEC_Axis.DriveLimits.PositionWindowNeg,local_SetValue1,NTEC_Axis.DriveLimits.PositionWindowPos) ]MOV(154,State);
   // State 154
   // Incremental Move command: wait for the AtTarget to come back ON, as the move completes.
   48: XIC(Enable_Command)EQU(State,154)[XIC(NTEC_Axis.StatMotion_AtTarget) ,ADD(local_SetValue1,StartingPosition,EndPosition) SUB(NTEC_Axis.PDI_Status.PositionActualValue,EndPosition,Delta) LIM(NTEC_Axis.DriveLimits.PositionWindowNeg,Delta,NTEC_Axis.DriveLimits.PositionWindowPos) ]MOV(160,State);
