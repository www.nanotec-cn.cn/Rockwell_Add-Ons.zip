(* Logix 5000 Program export MainProgram; software revision 35.00; part 5 of 7 *)
(* tags used below, declared in another part *)
   Value : DINT;   // WriteValue
(* NTEC_WRITE, continued *)

ROUTINE Postscan   (* ladder *)
// Home Post-Scan Routine
   // ***
   // POST SCAN ROUTINE
   // ***
   0: NOP();
   // ***
   // POST-SCAN ROUTINE
   // ***
   1: OTU(NTEC_Axis.PDI_CMD.Trig)NOP();
   2: OTU(EN);
END_ROUTINE

ROUTINE Prescan   (* ladder *)
// Home Pre-Scan Routine
   // ***
   // PRESCAN ROUTINE
   // ***
   0: NOP();
   1: OTU(ERR)CLR(ERR_Code);
   2: LIM(1,State,899)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(DN)OTU(EN)CLR(State);
END_ROUTINE
END_ADD_ON_INSTRUCTION

ADD_ON_INSTRUCTION NTEC_MAJ   (* revision 1.5, vendor Third Coast Automation, Nashville, TN, ExecutePrescan, ExecuteEnableInFalse *)
// Motion Axis Jog (MAJ)
// Jog the servo axis at a constant velocity.  After this AOI instruction executes, the axis continues to Jog until a Stop (NTEC_MAS) is executed.
// All input parameters are entered into the AOI in whole numbers, in the units as setup and scaled in the Drive.
// Revision note:
// Release Aug 27, 2024, update CPS instructions LEN
// Help:
// AOI written by:
// Tim Cochran
// Third Coast Automation
// Nashville, TN
// Motion Axis Jog (MAJ)
// Jog the servo axis at a constant velocity.  After this AOI instruction executes, the axis continues to Jog until a Stop (NTEC_MAS) is executed.
// MAJ ERR_Codes:
// 2: Input parameter range error – review and fix input parameters.
// 3: Command Error response from the Drive after command sent.
// 4: Command Error after Accel value was sent to the Drive.
// 5: Command Error after Decel value was sent to the Drive.
// 10: Communications Failed to Drive.
// 11: Drive Fault during this AOIs command sequence.
// 12: Quick Stop triggered by software outside of this AOI.
// 13: Command Error response from the Drive.
// 14: Enable input changed to False during sequence due to Drive Fault or Offline.
VAR_IN_OUT
   NTEC_Axis : NTEC_Axis; {required}   // NTEC Axis Tag
END_VAR
VAR_INPUT
   Velocity : DINT; {required}   // Velocity in Drive units / sec
   Acceleration : DINT; {required}   // Accel in Drive units/sec^2
   Deceleration : DINT; {required}   // Decel in Drive units/sec^2
END_VAR
VAR_OUTPUT
   EN : BOOL; {access Read Only, visible}   // Enabled
   IP : BOOL; {visible}   // In Process
   DN : BOOL; {visible}   // Successfully Done
   ERR : BOOL; {visible}   // Instruction Error
   ERR_Code : DINT; {access Read Only, visible}   // Instruction Error Code
END_VAR
VAR
   State : DINT; {access None}
   Enable : BOOL; {access None}
   local_Acceleration : DINT; {access None}
   InputRangesOK : BOOL; {access None}
   tmr_Verify : TIMER := (PRE := 10); {access None}
   local_Deceleration : DINT; {access None}
   local_Velocity : INT; {access None}
   Write1_cntrl : NTEC_WRITE; {access None}
   Write2_cntrl : NTEC_WRITE; {access None}
   VelocityDelta : DINT; {access None}
   LowLimit : DINT := -100; {access None}
   HighLimit : DINT := 100; {access None}
   neg_local_Velocity : DINT; {access None}
END_VAR

ROUTINE EnableInFalse   (* ladder *)
// Enable In False Routine
   // ***
   // Enable In False Routine
   // Runs when the rung to ths AOI instance is False
   // ***
   0: NOP();
   1: XIC(NTEC_Axis.StatResettingFault)OTU(ERR)CLR(ERR_Code);
   2: XIC(EN)LIM(1,State,899)XIC(NTEC_Axis.PDI_CMD.Trig)MOV(0,NTEC_Axis.PDI_CMD.SetValue1)MOV(0,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)OTU(IP)CLR(State);
END_ROUTINE

ROUTINE Logic   (* ladder *)
   // ***
   // Nanotec Motion Axis Jog
   // (Profile Velocity)
   // ***
   0: NOP();
   // ***
   // Main Logic Routine
   // ***
   1: NOP();
   // If the Enable (EN) bit is not on yet, this is first scan, so unlatch the Done (DN) bit.
   2: XIO(EN)OTU(DN);
   // Latch Enable (EN) bit as long as this AOI is being executed.
   3: XIC(EnableIn)OTE(EN);
   4: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)XIO(NTEC_Axis.StatDriveFault)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.QuickStop)XIO(NTEC_Axis.CMD_ERR)OTE(Enable);
   // Step 0
   // Start the Move Sequence
   5: XIC(Enable)EQU(State,0)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.Trig)XIO(NTEC_Axis.CMD_IP)MOV(100,State);
   // State 100
   // Verify input values are within acceptable ranges
   6: XIC(Enable)EQU(State,100)MOV(Velocity,local_Velocity)MOV(Acceleration,local_Acceleration)MOV(Deceleration,local_Deceleration)[LIM(NTEC_Axis.DriveLimits.MotorSpeedMin,local_Velocity,NTEC_Axis.DriveLimits.MotorSpeedMax) LIM(1,local_Acceleration,NTEC_Axis.DriveLimits.AccelLimitMax) LIM(1,local_Deceleration,NTEC_Axis.DriveLimits.DecelLimitMax) OTE(InputRangesOK) ,XIC(InputRangesOK) XIO(Write1_cntrl.EN) MOV(110,State) ,XIO(InputRangesOK) MOV(920,State) ];
   // State 110
   // Write Acceleration Value to the Drive
   // Profile Acceleration is object 6083h
   7: XIC(Enable)EQU(State,110)[NTEC_WRITE(Write1_cntrl,NTEC_Axis,16#6083,0,local_Acceleration) ,XIC(Write1_cntrl.DN) XIC(Write1_cntrl.EN) XIO(Write2_cntrl.EN) MOV(112,State) ,XIC(Write1_cntrl.ERR) MOV(940,State) ];
   // State 110
   // Write Deceleration Value to the Drive
   // Profile Acceleration is object 6084h
   8: XIC(Enable)EQU(State,112)[NTEC_WRITE(Write2_cntrl,NTEC_Axis,16#6084,0,local_Deceleration) ,XIC(Write2_cntrl.DN) XIC(Write2_cntrl.EN) MOV(120,State) ,XIC(Write2_cntrl.ERR) MOV(950,State) ];
   // State 120
   // Load the parameters and command to send to the NTEC_Comms AOI.
   9: XIC(Enable)EQU(State,120)MOV(local_Velocity,NTEC_Axis.PDI_CMD.SetValue1)MOV(0,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(23,NTEC_Axis.PDI_CMD.CMD)MOV(130,State);
   // State 130
   // Trigger the Velocity Command.
   10: XIC(Enable)EQU(State,130)OTL(NTEC_Axis.PDI_CMD.Trig)OTL(IP)MOV(140,State);
   // State 140
   11: XIC(Enable)EQU(State,140)MOV(150,State);
   // State 150
   // Verify the NTEC_Comms is In-Process (IP) sending  the command to the Drive.
   12: XIC(Enable)EQU(State,150)XIC(NTEC_Axis.CMD_IP)MOV(160,State);
   // State 160
   // Verify the NTEC_Comms is Done (DN) sending the command.
   13: XIC(Enable)EQU(State,160)TON(tmr_Verify,?,?)XIC(tmr_Verify.DN)XIC(NTEC_Axis.CMD_DN)MOV(170,State);
   // State 170
   // To finish the handshake with NTEC_Comms, this AOI clears the CMD_Trg and then NTEC_Comms clears its IP bit.
   14: XIC(Enable)EQU(State,170)MOV(0,NTEC_Axis.PDI_CMD.SetValue1)MOV(0,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig)MOV(180,State);
   // State 180
   // To finish the handshake with NTEC_Comms,NTEC_Comms clears its IP bit.
   15: XIC(Enable)EQU(State,180)XIO(NTEC_Axis.CMD_IP)MOV(190,State);
   // State 190
   // Clear the In Process Bit
   // Set the Done Bit
   // Move State to 1000, which is a rest state unitl the rung into this AOI is false.
   // END OF COMMAND SEQUENCE
   16: XIC(Enable)EQU(State,190)OTU(IP)OTL(DN)MOV(1000,State);
   // *************************************************
   // FAULTS
   17: NOP();
   // IF in the middle of a sequence AND the Drive Communications goes False, goto error state 910
   18: XIO(NTEC_Axis.StatDriveCommsOK)LIM(1,State,899)MOV(910,State);
   // Fault State 910
   // Communications to the Drive was  lost during a sequence - Abort the sequence.
   19: EQU(State,910)OTL(ERR)MOV(10,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the Drive Fault, goto error state 911
   20: XIC(NTEC_Axis.StatDriveFault)LIM(1,State,899)MOV(911,State);
   // Fault State 910
   // Drive Fault during a sequence - Abort the sequence
   21: EQU(State,911)OTL(ERR)MOV(11,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the QuickStop, goto error state 912
   22: XIC(NTEC_Axis.PDI_CMD.QuickStop)LIM(1,State,899)MOV(912,State);
   // Fault State 912
   // Quick Stop during a sequence - Abort the sequence
   23: EQU(State,912)OTL(ERR)MOV(12,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND Communications Command Error occurs, goto error state 913
   24: XIC(NTEC_Axis.CMD_ERR)LIM(1,State,899)MOV(913,State);
   // Fault State 913
   // Communications Command Error during a sequence - Abort the sequence and issue a Quick Stop
   25: EQU(State,913)OTL(ERR)MOV(13,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the EnableIn goes False, goto error state 914
   26: XIO(Enable)LIM(1,State,899)MOV(914,State);
   // Fault State 914
   // Enable Input changed to False / OFF during a sequence - Abort the sequence
   27: EQU(State,914)OTL(ERR)MOV(14,ERR_Code)MOV(999,State);
   // Fault State 920
   // Input Parameter Range Error
   28: EQU(State,920)OTL(ERR)MOV(2,ERR_Code)MOV(999,State);
   // Fault State - command error during sequence
   // IF in the middle of a sequence, this AOI receives a Command Error, goto error state 930
   29: XIC(NTEC_Axis.StatCommandError)LIM(100,State,899)MOV(930,State);
   // Fault State 930
   // Command Error during a sequence - Abort the sequence
   30: EQU(State,930)OTL(NTEC_Axis.PDI_CMD.QuickStop)OTL(ERR)MOV(3,ERR_Code)MOV(999,State);
   // Fault State 940
   // Send Accel to the Drive created an Error - Abort the sequence
   31: EQU(State,940)OTL(ERR)MOV(4,ERR_Code)MOV(999,State);
   // Fault State 950
   // Send Decel to the Drive created an Error - Abort the sequence
   32: EQU(State,950)OTL(ERR)MOV(5,ERR_Code)MOV(999,State);
   // Fault State 999
   // Clear the outputs after a Fault
   33: EQU(State,999)[MOV(0,NTEC_Axis.PDI_CMD.SetValue1) MOV(0,NTEC_Axis.PDI_CMD.SetValue2) MOV(0,NTEC_Axis.PDI_CMD.SetValue3) MOV(0,NTEC_Axis.PDI_CMD.CMD) ,OTU(NTEC_Axis.PDI_CMD.Trig) MOV(1000,State) ];
   // ********************************************************
   // State 1000
   // Wait for Enable In to go Off/On.  Just sit in this state until AOI triggered again.
   // Reset faults if the MAFT triggers a reset.  Reset if waiting is state 1000 OR state 0.
   34: [EQU(State,1000) ,EQU(State,0) ][NOP() ,XIC(NTEC_Axis.StatResettingFault) OTU(ERR) MOV(0,ERR_Code) ];
END_ROUTINE

ROUTINE Postscan   (* ladder *)
// Home Post-Scan Routine
   // ***
   // POST SCAN ROUTINE
   // ***
   0: NOP();
   // ***
   // POST-SCAN ROUTINE
   // ***
   1: OTU(NTEC_Axis.PDI_CMD.Trig)NOP();
   2: OTU(EN)OTU(IP);
END_ROUTINE

ROUTINE Prescan   (* ladder *)
// Home Pre-Scan Routine
   // ***
   // PRESCAN ROUTINE
   // ***
   0: NOP();
   1: OTU(ERR)CLR(ERR_Code);
   2: LIM(1,State,899)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)OTU(DN)OTU(IP)CLR(State);
END_ROUTINE
END_ADD_ON_INSTRUCTION

ADD_ON_INSTRUCTION NTEC_MAM   (* revision 1.5, vendor Third Coast Automation, Nashville, TN, ExecutePrescan, ExecuteEnableInFalse *)
// Motion Axis Move (MAM)
// Move the servo axis to a target position.
// Move Type:
// 1=Absolute
// 2=Incremental (Relative)
// All input parameters are entered into the AOI in whole numbers, in the units as setup and scaled in the Drive.
// Revision note:
// Release Aug 27, 2024, update CPS instructions LEN
// Help:
// AOI written by:
// Tim Cochran
// Third Coast Automation
// Nashville, TN
// MAM ERR_Codes:
// 2: Input parameter range error – review and fix input parameters.
// 3: Command Error response from the Drive after command sent.
// 4: Command Error after Accel value was sent to the Drive.
// 5: Command Error after Decel value was sent to the Drive.
// 10: Communications Failed to Drive.
// 11: Drive Fault during this AOIs command sequence.
// 12: Quick Stop triggered by software outside of this AOI.
// 13: Command Error response from the Drive.
// 14: Enable input changed to False during sequence due to Drive Fault or Offline.
VAR_IN_OUT
   NTEC_Axis : NTEC_Axis; {required}   // NTEC Axis Tag
END_VAR
VAR_INPUT
   MoveType : DINT; {required}   // 1=Absolute 2= Relative (Incremental)
   Position : DINT; {required}   // Position value for move location
   Velocity : DINT; {required}   // Velocity in Drive units / sec
   Acceleration : DINT; {required}   // Accel in Drive units/sec^2
   Deceleration : DINT; {required}   // Decel in Drive units/sec^2
END_VAR
VAR_OUTPUT
   EN : BOOL; {access Read Only, visible}   // Enabled
   IP : BOOL; {visible}   // In Process
   DN : BOOL; {visible}   // Successfully Done
   ERR : BOOL; {visible}   // Instruction Error
   ERR_Code : DINT; {access Read Only, visible}   // Instruction Error Code
END_VAR
VAR
   State : DINT; {access None}
   Enable : BOOL; {access None}
   local_MoveType : DINT := 2; {access None}
   local_Position : DINT; {access None}
   local_Acceleration : DINT; {access None}
   InputRangesOK : BOOL; {access None}
   tmr_Verify : TIMER := (PRE := 20); {access None}
   local_Deceleration : DINT; {access None}
   local_Velocity : INT; {access None}
   Write1_cntrl : NTEC_WRITE; {access None}
   Write2_cntrl : NTEC_WRITE; {access None}
   MoveStarted : BOOL; {access None}
   MovePositionDelta : DINT; {access None}
   LowLimitPositionWindow : DINT := -50; {access None}
   HighLimitPositionWindow : DINT := 50; {access None}
END_VAR

ROUTINE EnableInFalse   (* ladder *)
// Enable In False Routine
   // ***
   // Enable In False Routine
   // Runs when the rung to ths AOI instance is False
   // ***
   0: NOP();
   1: XIC(NTEC_Axis.StatResettingFault)OTU(ERR)CLR(ERR_Code);
   2: XIC(EN)LIM(1,State,899)XIC(NTEC_Axis.PDI_CMD.Trig)MOV(0,NTEC_Axis.PDI_CMD.SetValue1)MOV(0,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)OTU(IP)CLR(State);
   4: OTU(MoveStarted);
END_ROUTINE

ROUTINE Logic   (* ladder *)
   // ***
   // Nanotec Motion Axis Move
   // (Profile Position)
   // ***
   0: NOP();
   // ***
   // Main Logic Routine
   // ***
   1: NOP();
   // If the Enable (EN) bit is not on yet, this is first scan, so unlatch the Done (DN) bit.
   2: XIO(EN)OTU(DN);
   // Latch Enable (EN) bit as long as this AOI is being executed.
   3: XIC(EnableIn)OTE(EN);
   4: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)XIO(NTEC_Axis.StatDriveFault)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.QuickStop)XIO(NTEC_Axis.CMD_ERR)OTE(Enable);
   // Step 0
   // Start the Move Sequence
   5: XIC(Enable)EQU(State,0)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.Trig)XIO(NTEC_Axis.CMD_IP)MOV(100,State);
   // State 100
   // Verify input values are within acceptable ranges
   6: XIC(Enable)EQU(State,100)MOV(MoveType,local_MoveType)MOV(Position,local_Position)MOV(Velocity,local_Velocity)MOV(Acceleration,local_Acceleration)MOV(Deceleration,local_Deceleration);
   // State 100
   // Verify input values are within acceptable ranges
   7: XIC(Enable)EQU(State,100)LIM(1,local_MoveType,2)[LIM(NTEC_Axis.DriveLimits.PositionLimitMin,local_Position,NTEC_Axis.DriveLimits.PositionLimitMax) ,EQU(NTEC_Axis.DriveLimits.PositionLimitMin,0) EQU(NTEC_Axis.DriveLimits.PositionLimitMax,0) ][LIM(NTEC_Axis.DriveLimits.SoftPositionLimitMin,local_Position,NTEC_Axis.DriveLimits.SoftPositionLimitMax) ,EQU(NTEC_Axis.DriveLimits.SoftPositionLimitMin,0) EQU(NTEC_Axis.DriveLimits.SoftPositionLimitMax,0) ]LIM(NTEC_Axis.DriveLimits.MotorSpeedMin,local_Velocity,NTEC_Axis.DriveLimits.MotorSpeedMax)NEQ(local_Velocity,0)LIM(1,local_Acceleration,NTEC_Axis.DriveLimits.AccelLimitMax)LIM(1,local_Deceleration,NTEC_Axis.DriveLimits.DecelLimitMax)OTE(InputRangesOK);
   // State 100
   // Verify input values are within acceptable ranges
   8: XIC(Enable)EQU(State,100)[XIC(InputRangesOK) XIO(Write1_cntrl.EN) MOV(110,State) ,XIO(InputRangesOK) MOV(920,State) ];
   // State 110
   // Write Acceleration Value to the Drive
   // Profile Acceleration is object 6083h
   9: XIC(Enable)EQU(State,110)[XIC(NTEC_Axis.StatMotion_AtTarget) ,XIO(NTEC_Axis.StatServoActionStatus) ][NTEC_WRITE(Write1_cntrl,NTEC_Axis,16#6083,0,local_Acceleration) ,XIC(Write1_cntrl.DN) XIC(Write1_cntrl.EN) XIO(Write2_cntrl.EN) MOV(112,State) ,XIC(Write1_cntrl.ERR) MOV(940,State) ];
   // State 112
   // Write Deceleration Value to the Drive
   // Profile Acceleration is object 6084h
   10: XIC(Enable)EQU(State,112)[NTEC_WRITE(Write2_cntrl,NTEC_Axis,16#6084,0,local_Deceleration) ,XIC(Write2_cntrl.DN) XIC(Write2_cntrl.EN) [EQU(local_MoveType,1) MOV(120,State) ,EQU(local_MoveType,2) MOV(122,State) ] ,XIC(Write2_cntrl.ERR) MOV(950,State) ];
   // State 120
   // Absolute Move
   // Based on the Move Type, select the correct parameters and command to send to the NTEC_Comms AOI.
   11: XIC(Enable)EQU(State,120)MOV(local_Position,NTEC_Axis.PDI_CMD.SetValue1)MOV(local_Velocity,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(20,NTEC_Axis.PDI_CMD.CMD)MOV(130,State);
   // State 122
   // Relative (Incremental) Move
   // Based on the Move Type, select the correct parameters and command to send to the NTEC_Comms AOI.
   12: XIC(Enable)EQU(State,122)MOV(local_Position,NTEC_Axis.PDI_CMD.SetValue1)MOV(local_Velocity,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(21,NTEC_Axis.PDI_CMD.CMD)MOV(130,State);
   // State 130
   // Trigger the Move Command.
   13: XIC(Enable)EQU(State,130)OTL(NTEC_Axis.PDI_CMD.Trig)OTL(IP)MOV(140,State);
   // State 140
   14: XIC(Enable)EQU(State,140)OTL(MoveStarted)MOV(150,State);
   // State 150
   // Verify the NTEC_Comms is In-Process (IP) sending  the command to the Drive.
   15: XIC(Enable)EQU(State,150)XIC(NTEC_Axis.CMD_IP)MOV(160,State);
   // State 160
   // Verify the NTEC_Comms is Done (DN) sending the command.
   16: XIC(Enable)EQU(State,160)TON(tmr_Verify,?,?)XIC(tmr_Verify.DN)XIC(NTEC_Axis.CMD_DN)OTU(MoveStarted)MOV(170,State);
   // State 170
   // To finish the handshake with NTEC_Comms, this AOI clears the CMD_Trg and then NTEC_Comms clears its IP bit.
   17: XIC(Enable)EQU(State,170)MOV(0,NTEC_Axis.PDI_CMD.SetValue1)MOV(0,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig)MOV(180,State);
   // State 180
   // To finish the handshake with NTEC_Comms,NTEC_Comms clears its IP bit.
   18: XIC(Enable)EQU(State,180)XIO(NTEC_Axis.CMD_IP)MOV(190,State);
   // State 190
   // Clear the In Process Bit
   // Set the Done Bit
   // Move State to 1000, which is a rest state unitl the rung into this AOI is false.
   // END OF COMMAND SEQUENCE
   19: XIC(Enable)EQU(State,190)OTU(IP)OTL(DN)MOV(1000,State);
   // *************************************************
   // FAULTS
   20: NOP();
   // IF in the middle of a sequence AND the Drive Communications goes False, goto error state 910
   21: XIO(NTEC_Axis.StatDriveCommsOK)LIM(1,State,899)MOV(910,State);
   // Fault State 910
   // Communications to the Drive was  lost during a sequence - Abort the sequence.
   22: EQU(State,910)OTL(ERR)MOV(10,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the Drive Fault, goto error state 911
   23: XIC(NTEC_Axis.StatDriveFault)LIM(1,State,899)MOV(911,State);
   // Fault State 910
   // Drive Fault during a sequence - Abort the sequence
   24: EQU(State,911)OTL(ERR)MOV(11,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the QuickStop, goto error state 912
   25: XIC(NTEC_Axis.PDI_CMD.QuickStop)LIM(1,State,899)MOV(912,State);
   // Fault State 912
   // Quick Stop during a sequence - Abort the sequence
   26: EQU(State,912)OTL(ERR)MOV(12,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND Communications Command Error occurs, goto error state 913
   27: XIC(NTEC_Axis.CMD_ERR)LIM(1,State,899)MOV(913,State);
   // Fault State 913
   // Communications Command Error during a sequence - Abort the sequence and issue a Quick Stop
   28: EQU(State,913)OTL(ERR)MOV(13,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the EnableIn goes False, goto error state 914
   29: XIO(Enable)LIM(1,State,899)MOV(914,State);
   // Fault State 914
   // Enable Input changed to False / OFF during a sequence - Abort the sequence
   30: EQU(State,914)OTL(ERR)MOV(14,ERR_Code)MOV(999,State);
   // Fault State 920
   // Input Parameter Range Error
   31: EQU(State,920)OTL(ERR)MOV(2,ERR_Code)MOV(999,State);
   // Fault State - command error during sequence
   // IF in the middle of a sequence, this AOI receives a Command Error, goto error state 930
   32: XIC(NTEC_Axis.StatCommandError)LIM(100,State,899)MOV(930,State);
   // Fault State 930
   // Command Error during a sequence - Abort the sequence
   33: EQU(State,930)OTL(NTEC_Axis.PDI_CMD.QuickStop)OTL(ERR)MOV(3,ERR_Code)MOV(999,State);
   // Fault State 940
   // Send Accel to the Drive created an Error - Abort the sequence
   34: EQU(State,940)OTL(ERR)MOV(4,ERR_Code)MOV(999,State);
   // Fault State 950
   // Send Decel to the Drive created an Error - Abort the sequence
   35: EQU(State,950)OTL(ERR)MOV(5,ERR_Code)MOV(999,State);
   // Fault State 999
   // Clear the outputs after a Fault
   36: EQU(State,999)[MOV(0,NTEC_Axis.PDI_CMD.SetValue1) MOV(0,NTEC_Axis.PDI_CMD.SetValue2) MOV(0,NTEC_Axis.PDI_CMD.SetValue3) MOV(0,NTEC_Axis.PDI_CMD.CMD) ,OTU(NTEC_Axis.PDI_CMD.Trig) MOV(1000,State) ];
   // ********************************************************
   // State 1000
   // Wait for Enable In to go Off/On.  Just sit in this state until AOI triggered again.
   // Reset faults if the MAFT triggers a reset.  Reset if waiting is state 1000 OR state 0.
   37: [EQU(State,1000) ,EQU(State,0) ][NOP() ,XIC(NTEC_Axis.StatResettingFault) OTU(ERR) MOV(0,ERR_Code) ];
END_ROUTINE
