(* Logix 5000 Program export MainProgram; software revision 35.00; part 6 of 7 *)
(* tags used below, declared in another part *)
   MoveType : DINT;   // 1=Absolute 2= Relative (Incremental)
   Position : DINT;   // Position value for move location
   Velocity : DINT;   // Velocity in Drive units / sec
   Acceleration : DINT;   // Accel in Drive units/sec^2
(* NTEC_MAM, continued *)

ROUTINE Postscan   (* ladder *)
// Home Post-Scan Routine
   // ***
   // POST SCAN ROUTINE
   // ***
   0: NOP();
   // ***
   // POST-SCAN ROUTINE
   // ***
   1: OTU(NTEC_Axis.PDI_CMD.Trig)NOP();
   2: OTU(EN)OTU(IP);
END_ROUTINE

ROUTINE Prescan   (* ladder *)
// Home Pre-Scan Routine
   // ***
   // PRESCAN ROUTINE
   // ***
   0: NOP();
   1: OTU(ERR)CLR(ERR_Code);
   2: LIM(1,State,899)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)OTU(DN)OTU(IP)CLR(State);
END_ROUTINE
END_ADD_ON_INSTRUCTION

ADD_ON_INSTRUCTION NTEC_MAS   (* revision 1.5, vendor Third Coast Automation, Nashville, TN, ExecutePrescan, ExecuteEnableInFalse *)
// Motion Axis Stop (MAS)
// Set the servo axis to a constant velocity=0.
// Revision note:
// Release Aug 27, 2024, update CPS instructions LEN
// Help:
// AOI written by:
// Tim Cochran
// Third Coast Automation
// Nashville, TN
// MAS ERR_Codes:
// 2: Input parameter range error – review and fix input parameters.
// 3: Command Error response from the Drive after command sent.
// 4: Command Error after Decel value was sent to the Drive.
// 10: Communications Failed to Drive.
// 11: Drive Fault during this AOIs command sequence.
// 12: Quick Stop triggered by software outside of this AOI.
// 13: Command Error response from the Drive.
// 14: Enable input changed to False during sequence due to Drive Fault or Offline.
VAR_IN_OUT
   NTEC_Axis : NTEC_Axis; {required}   // NTEC Axis Tag
END_VAR
VAR_INPUT
   Deceleration : DINT; {required}   // Decel in Drive units/sec^2
END_VAR
VAR_OUTPUT
   EN : BOOL; {access Read Only, visible}   // Enabled
   IP : BOOL; {visible}   // In Process
   DN : BOOL; {visible}   // Successfully Done
   ERR : BOOL; {visible}   // Instruction Error
   ERR_Code : DINT; {access Read Only, visible}   // Instruction Error Code
END_VAR
VAR
   State : DINT; {access None}
   Enable : BOOL; {access None}
   InputRangesOK : BOOL; {access None}
   tmr_Verify : TIMER := (PRE := 100); {access None}
   local_Deceleration : DINT; {access None}
   Write2_cntrl : NTEC_WRITE; {access None}
END_VAR

ROUTINE EnableInFalse   (* ladder *)
// Enable In False Routine
   // ***
   // Enable In False Routine
   // Runs when the rung to ths AOI instance is False
   // ***
   0: NOP();
   1: XIC(NTEC_Axis.StatResettingFault)OTU(ERR)CLR(ERR_Code);
   2: XIC(EN)LIM(1,State,899)XIC(NTEC_Axis.PDI_CMD.Trig)MOV(0,NTEC_Axis.PDI_CMD.SetValue1)MOV(0,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)OTU(IP)CLR(State);
END_ROUTINE

ROUTINE Logic   (* ladder *)
   // ***
   // Nanotec Motion Axis Stop
   // (Profile Velocity)
   // ***
   0: NOP();
   // ***
   // Main Logic Routine
   // ***
   1: NOP();
   // If the Enable (EN) bit is not on yet, this is first scan, so unlatch the Done (DN) bit.
   2: XIO(EN)OTU(DN);
   // Latch Enable (EN) bit as long as this AOI is being executed.
   3: XIC(EnableIn)OTE(EN);
   4: XIC(EnableIn)XIC(NTEC_Axis.StatDriveCommsOK)XIO(NTEC_Axis.StatDriveFault)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.QuickStop)XIO(NTEC_Axis.CMD_ERR)OTE(Enable);
   // Step 0
   // Start the Move Sequence
   5: XIC(Enable)EQU(State,0)XIO(ERR)XIO(NTEC_Axis.PDI_CMD.Trig)XIO(NTEC_Axis.CMD_IP)MOV(100,State);
   // State 100
   // Verify input values are within acceptable ranges
   6: XIC(Enable)EQU(State,100)MOV(Deceleration,local_Deceleration)[LIM(1,local_Deceleration,NTEC_Axis.DriveLimits.DecelLimitMax) OTE(InputRangesOK) ,XIC(InputRangesOK) XIO(Write2_cntrl.EN) MOV(112,State) ,XIO(InputRangesOK) MOV(920,State) ];
   // State 110
   // Write Deceleration Value to the Drive
   // Profile Acceleration is object 6084h
   7: XIC(Enable)EQU(State,112)[NTEC_WRITE(Write2_cntrl,NTEC_Axis,16#6084,0,local_Deceleration) ,XIC(Write2_cntrl.DN) XIC(Write2_cntrl.EN) MOV(120,State) ,XIC(Write2_cntrl.ERR) MOV(950,State) ];
   // State 120
   // Load the parameters and command to send to the NTEC_Comms AOI.
   8: XIC(Enable)EQU(State,120)MOV(0,NTEC_Axis.PDI_CMD.SetValue1)MOV(0,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(23,NTEC_Axis.PDI_CMD.CMD)MOV(130,State);
   // State 130
   // Trigger the Move Command.
   9: XIC(Enable)EQU(State,130)OTL(NTEC_Axis.PDI_CMD.Trig)OTL(IP)MOV(140,State);
   // State 140
   10: XIC(Enable)EQU(State,140)MOV(150,State);
   // State 150
   // Verify the NTEC_Comms is In-Process (IP) sending  the command to the Drive.
   11: XIC(Enable)EQU(State,150)XIC(NTEC_Axis.CMD_IP)MOV(160,State);
   // State 160
   // Verify the "At Target" is returned from the Drive.
   // Verify the NTEC_Comms is Done (DN) sending the command.
   12: XIC(Enable)EQU(State,160)[TON(tmr_Verify,?,?) XIC(tmr_Verify.DN) ,LES(NTEC_Axis.PDI_Status.VelocityActualValue,10) ]XIC(NTEC_Axis.StatMotion_AtTarget)XIC(NTEC_Axis.CMD_DN)MOV(170,State);
   // State 170
   // To finish the handshake with NTEC_Comms, this AOI clears the CMD_Trg and then NTEC_Comms clears its IP bit.
   13: XIC(Enable)EQU(State,170)MOV(0,NTEC_Axis.PDI_CMD.SetValue1)MOV(0,NTEC_Axis.PDI_CMD.SetValue2)MOV(0,NTEC_Axis.PDI_CMD.SetValue3)MOV(0,NTEC_Axis.PDI_CMD.CMD)OTU(NTEC_Axis.PDI_CMD.Trig)MOV(180,State);
   // State 180
   // To finish the handshake with NTEC_Comms,NTEC_Comms clears its IP bit.
   14: XIC(Enable)EQU(State,180)XIO(NTEC_Axis.CMD_IP)MOV(190,State);
   // State 190
   // Clear the In Process Bit
   // Set the Done Bit
   // Move State to 1000, which is a rest state unitl the rung into this AOI is false.
   // END OF COMMAND SEQUENCE
   15: XIC(Enable)EQU(State,190)OTU(IP)OTL(DN)MOV(1000,State);
   // *************************************************
   // FAULTS
   16: NOP();
   // IF in the middle of a sequence AND the Drive Communications goes False, goto error state 910
   17: XIO(NTEC_Axis.StatDriveCommsOK)LIM(1,State,899)MOV(910,State);
   // Fault State 910
   // Communications to the Drive was  lost during a sequence - Abort the sequence.
   18: EQU(State,910)OTL(ERR)MOV(10,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the Drive Fault, goto error state 911
   19: XIC(NTEC_Axis.StatDriveFault)LIM(1,State,899)MOV(911,State);
   // Fault State 910
   // Drive Fault during a sequence - Abort the sequence
   20: EQU(State,911)OTL(ERR)MOV(11,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the QuickStop, goto error state 912
   21: XIC(NTEC_Axis.PDI_CMD.QuickStop)LIM(1,State,899)MOV(912,State);
   // Fault State 912
   // Quick Stop during a sequence - Abort the sequence
   22: EQU(State,912)OTL(ERR)MOV(12,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND Communications Command Error occurs, goto error state 913
   23: XIC(NTEC_Axis.CMD_ERR)LIM(1,State,899)MOV(913,State);
   // Fault State 913
   // Communications Command Error during a sequence - Abort the sequence and issue a Quick Stop
   24: EQU(State,913)OTL(ERR)MOV(13,ERR_Code)MOV(999,State);
   // IF in the middle of a sequence AND the EnableIn goes False, goto error state 914
   25: XIO(Enable)LIM(1,State,899)MOV(914,State);
   // Fault State 914
   // Enable Input changed to False / OFF during a sequence - Abort the sequence
   26: EQU(State,914)OTL(ERR)MOV(14,ERR_Code)MOV(999,State);
   // Fault State 920
   // Input Parameter Range Error
   27: EQU(State,920)OTL(ERR)MOV(2,ERR_Code)MOV(999,State);
   // Fault State - command error during sequence
   // IF in the middle of a sequence, this AOI receives a Command Error, goto error state 930
   28: XIC(NTEC_Axis.StatCommandError)LIM(100,State,899)MOV(930,State);
   // Fault State 930
   // Command Error during a sequence - Abort the sequence
   29: EQU(State,930)OTL(NTEC_Axis.PDI_CMD.QuickStop)OTL(ERR)MOV(3,ERR_Code)MOV(999,State);
   // Fault State 950
   // Send Decel to the Drive created an Error - Abort the sequence
   30: EQU(State,950)OTL(ERR)MOV(4,ERR_Code)MOV(999,State);
   // Fault State 999
   // Clear the outputs after a Fault
   31: EQU(State,999)[MOV(0,NTEC_Axis.PDI_CMD.SetValue1) MOV(0,NTEC_Axis.PDI_CMD.SetValue2) MOV(0,NTEC_Axis.PDI_CMD.SetValue3) MOV(0,NTEC_Axis.PDI_CMD.CMD) ,OTU(NTEC_Axis.PDI_CMD.Trig) MOV(1000,State) ];
   // ********************************************************
   // State 1000
   // Wait for Enable In to go Off/On.  Just sit in this state until AOI triggered again.
   // Reset faults if the MAFT triggers a reset.  Reset if waiting is state 1000 OR state 0.
   32: [EQU(State,1000) ,EQU(State,0) ][NOP() ,XIC(NTEC_Axis.StatResettingFault) OTU(ERR) MOV(0,ERR_Code) ];
END_ROUTINE

ROUTINE Postscan   (* ladder *)
// Home Post-Scan Routine
   // ***
   // POST SCAN ROUTINE
   // ***
   0: NOP();
   // ***
   // POST-SCAN ROUTINE
   // ***
   1: OTU(NTEC_Axis.PDI_CMD.Trig)NOP();
   2: OTU(EN)OTU(IP);
END_ROUTINE

ROUTINE Prescan   (* ladder *)
// Home Pre-Scan Routine
   // ***
   // PRESCAN ROUTINE
   // ***
   0: NOP();
   1: OTU(ERR)CLR(ERR_Code);
   2: LIM(1,State,899)OTU(NTEC_Axis.PDI_CMD.Trig);
   3: OTU(EN)OTU(DN)OTU(IP)CLR(State);
END_ROUTINE
END_ADD_ON_INSTRUCTION

VAR_GLOBAL   (* controller tags *)
   always_off : BOOL;
END_VAR

PROGRAM MainProgram   (* main routine MainRoutine *)
VAR
   Always_ON : BOOL;
   Axis1Position : DINT[100];
   Axis2Position : DINT[100];
   cntrl_FaultReset : NTEC_MAFR;
   cntrl_Home : NTEC_MAH := (Position := 1, HomeType := 1, DN := 1);
   cntrl_Jog1 : NTEC_MAJ := (Velocity := 2000, Acceleration := 500, Deceleration := 500, DN := 1);
   cntrl_Move1 : NTEC_MAM := (MoveType := 2, Position := 100000, Velocity := 2000, Acceleration := 2000, Deceleration := 500, DN := 1);
   cntrl_Move2 : NTEC_MAM := (MoveType := 1, Position := 100, Velocity := 2000, Acceleration := 500, Deceleration := 500, DN := 1);
   cntrl_NTEC_Comms : NTEC_Comms := (EN := 1);
   cntrl_NTEC_Comms2 : NTEC_Comms;
   cntrl_NTEC_Read : NTEC_READ;
   cntrl_Stop1 : NTEC_MAS := (Deceleration := 500, DN := 1);
   EnableTestSeq : BOOL;
   FaultBits : DINT[2];
   HomeMethod : DINT;
   HomePosition : DINT := 1000;
   HomeType : DINT := 1;   // 1=Immediate 2=Sensor 3=Block
   JogTimer : TIMER := (PRE := 5000);
   Move1Accel : DINT := 2000;
   Move1Decel : DINT := 500;
   Move1Position : DINT := 100000;
   Move1Type : DINT := 2;
   Move1Velocity : DINT := 2000;
   Move2Accel : DINT := 500;
   Move2Decel : DINT := 500;
   Move2Position : DINT := 100;
   Move2Type : DINT := 1;
   Move2Velocity : DINT := 2000;
   NTEC_Axis1 : NTEC_Axis := (StatDriveCommsOK := 1, StatMotion_Halt := 1, StatMotion_Homed := 1, StatReadResponse := 1000, CMD_DN := 1, PDI_Status.Status := 2176, PDI_Status.PositionActualValue := 124725, PDI_Status.DigitalInputs := 8, PDI_Status.AnalogInput1 := 623, DriveLimits.VelocityLimitMax := 5000, DriveLimits.MotorSpeedMax := 30000, DriveLimits.AccelLimitMax := 5000, DriveLimits.DecelLimitMax := 5000, DriveLimits.PositionWindowPos := 40, DriveLimits.VelocityWindowPos := 100, DriveLimits.TorqueMaxPosDir := 1000, DriveLimits.CurrentMaxPosDir := 1000);
   OneShot : DINT := 2084;
   pb_ResetErr : BOOL;
   pb_Start : BOOL;
   pb_Stop : BOOL;
   State : DINT;
   StationFaulted : BOOL;
END_VAR

ROUTINE MachineSequence   (* ladder *)
   // ***
   // Test Code
   // Machine Sequence
   // ***
   0: NOP();
   // ***
   // Call the NanotecDrive Communications AOI every scan.
   // Create one comms AOI for every Drive.
   // ***
   1: NTEC_Comms(cntrl_NTEC_Comms,NTEC_Axis1,NanotecDrive1:I1.Data,NanotecDrive1:O1.Data,NanotecDrive1:I1.ConnectionFaulted);
   // Just for ease of viewing, place the status words here
   2: EQU(NTEC_Axis1.PDI_Status.Status,0)EQU(NTEC_Axis1.PDI_Status.ErrorCode,0)EQU(NTEC_Axis1.PDI_Status.ReturnValue,0)EQU(NTEC_Axis1.PDI_Status.PositionActualValue,0)EQU(NTEC_Axis1.PDI_Status.VelocityActualValue,0)EQU(NTEC_Axis1.PDI_Status.FollowingError,0)XIC(NTEC_Axis1.PDI_CMD.Trig)NOP();
   // Press the Reset Error button to reset faults and errors
   3: XIC(pb_ResetErr)[NTEC_MAFR(cntrl_FaultReset,NTEC_Axis1) ,CLR(FaultBits[0]) CLR(FaultBits[1]) ];
   // Hit the Start PB to
   // Enable the Test Sequence to run.
   4: [XIC(pb_Start) ,XIC(EnableTestSeq) ]XIO(pb_Stop)XIO(StationFaulted)OTE(EnableTestSeq);
   // IF the Test Sequence stops, execute a quick stop and reset the sequence.
   5: XIO(EnableTestSeq)ONS(OneShot.2)[MOV(0,State) ,OTL(NTEC_Axis1.PDI_CMD.QuickStop) ];
   // ***
   // Start Test Sequence
   // ***
   6: XIC(EnableTestSeq)EQU(State,0)MOV(100,State);
   7: XIC(EnableTestSeq)EQU(State,100)[NTEC_MAH(cntrl_Home,NTEC_Axis1,HomePosition,HomeType,HomeMethod) ,XIC(cntrl_Home.EN) XIC(cntrl_Home.DN) MOV(110,State) ];
   8: XIC(EnableTestSeq)EQU(State,110)[NTEC_MAM(cntrl_Move1,NTEC_Axis1,Move1Type,Move1Position,Move1Velocity,Move1Accel,Move1Decel) ,XIC(cntrl_Move1.EN) XIC(cntrl_Move1.DN) MOV(120,State) ];
   9: XIC(EnableTestSeq)EQU(State,120)[NTEC_MAM(cntrl_Move2,NTEC_Axis1,Move2Type,Move2Position,Move2Velocity,Move2Accel,Move2Decel) ,XIC(cntrl_Move2.EN) XIC(cntrl_Move2.DN) MOV(130,State) ];
   10: XIC(EnableTestSeq)EQU(State,130)[NTEC_MAJ(cntrl_Jog1,NTEC_Axis1,Move2Velocity,Move2Accel,Move2Decel) ,XIC(cntrl_Jog1.EN) XIC(cntrl_Jog1.DN) MOV(140,State) ];
   11: XIC(EnableTestSeq)EQU(State,140)TON(JogTimer,?,?)XIC(JogTimer.DN)[NTEC_MAS(cntrl_Stop1,NTEC_Axis1,Move1Decel) ,XIC(cntrl_Stop1.EN) XIC(cntrl_Stop1.DN) XIC(EnableTestSeq) MOV(110,State) ];
   // *************************************
   // Faults
   // Trigger a fault for each instruction fault.
   12: NOP();
   13: NEQ(FaultBits[0],0)OTE(StationFaulted);
   14: XIC(cntrl_FaultReset.ERR)OTL(FaultBits[0].1);
   15: XIC(cntrl_Home.ERR)OTL(FaultBits[0].2);
   16: XIC(cntrl_Jog1.ERR)OTL(FaultBits[0].3);
   17: XIC(cntrl_Move1.ERR)OTL(FaultBits[0].4);
   18: XIC(cntrl_Move2.ERR)OTL(FaultBits[0].5);
   19: XIC(cntrl_Stop1.ERR)OTL(FaultBits[0].6);
END_ROUTINE
