(* Logix 5000 Program export MainProgram; software revision 35.00; part 7 of 7 *)
(* tags used below, declared in another part *)
   always_off : BOOL;
(* MainProgram, continued *)

ROUTINE MainRoutine   (* ladder *)
   // Always OFF bit for debug and diagnostics
   0: OTU(always_off);
   1: JSR(MachineSequence,0);
END_ROUTINE
END_PROGRAM
